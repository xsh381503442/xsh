#include "drv_lcd.h"
#include "am_mcu_apollo.h"
#include "am_util.h"
#include "SEGGER_RTT.h"

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>
#include <math.h>
#include <stdlib.h>


#include "font_char.h"
#include "font_chinese.h"
#include "font_number.h"

#define	DRV_LCD_LOG_ENABLED			1

#if DEBUG_ENABLED == 1 && DRV_LCD_LOG_ENABLED == 1
	#define DRV_LCD_LOG_WRITESTRING(...)			SEGGER_RTT_WriteString(0,__VA_ARGS__)
	#define DRV_LCD_LOG_PRINTF(...) 				SEGGER_RTT_printf(0,##__VA_ARGS__)
#else       
	#define DRV_LCD_LOG_WRITESTRING(...)
	#define DRV_LCD_LOG_PRINTF(...)		        
#endif

static bool m_enableEnb = false;
static uint8_t g_dispBuf[LCD_LINE_CNT_MAX][LCD_PIXEL_ONELINE_MAX];
#ifdef WATCH_COD_BSP 
//extern SemaphoreHandle_t Appolo_SPI_Semaphore;

uint8_t mp_flag = 0;

void bsp_iom_enable(uint32_t ui32Module,am_hal_iom_config_t iomConfig)
{
	//BSP_IOM_LOG_PRINTF("[bsp_iom]: bsp_iom_enable %d\n",ui32Module);
	
	// Power on the IOM
	am_hal_iom_pwrctrl_enable(ui32Module);

	// Configure IOM
	am_hal_iom_config(ui32Module,&iomConfig);

	switch(ui32Module)
	{
		case 1:
		//SPI1

			//am_hal_gpio_pin_config(BSP_GPIO_IOM1_SPI_MISO,BSP_GPIO_CFG_IOM1_SPI_MISO);
			am_hal_gpio_pin_config(BSP_GPIO_IOM1_SPI_SCK,BSP_GPIO_CFG_IOM1_SPI_SCK);
			am_hal_gpio_pin_config(BSP_GPIO_IOM1_SPI_MOSI,BSP_GPIO_CFG_IOM1_SPI_MOSI);
		
			break;
			default:
			//BSP_IOM_LOG_PRINTF("[bsp_iom]: bsp_iom_enable ui32Modeule is ERROR\n");
			break;
	}
	
	// Enable IOM
	am_hal_iom_enable(ui32Module);
}

void bsp_iom_disable(uint32_t ui32Module)
{
	//BSP_IOM_LOG_PRINTF("[bsp_iom]: bsp_iom_disable %d\n",ui32Module);
	
    // Disable IOM
    am_hal_iom_disable(ui32Module);
	
	// Power down IOM

	
	// Re-configure IOM pins during sleep
	switch(ui32Module)
    {
   
		case 1:
		//SPI1
			//am_hal_gpio_pin_config(BSP_GPIO_IOM1_SPI_MISO,AM_HAL_GPIO_INPUT|AM_HAL_GPIO_PULLUP);
			am_hal_gpio_pin_config(BSP_GPIO_IOM1_SPI_SCK,AM_HAL_GPIO_INPUT|AM_HAL_GPIO_PULLUP);
			am_hal_gpio_pin_config(BSP_GPIO_IOM1_SPI_MOSI,AM_HAL_GPIO_INPUT|AM_HAL_GPIO_PULLUP);
	
			break;
  
        default:
            //BSP_IOM_LOG_PRINTF("[bsp_iom]: bsp_iom_disable ui32Modeule is ERROR\n");
			break;
    }	
	
	am_hal_iom_pwrctrl_disable(ui32Module);
}

//*****************************************************************************
//
// Configuration structure for the IO Master.
//
//*****************************************************************************
const am_hal_iom_config_t g_sLCD_IOMConfig =
{
    .ui32InterfaceMode = AM_HAL_IOM_SPIMODE,
    .ui32ClockFrequency = AM_HAL_IOM_4MHZ,
    .bSPHA = 0,
    .bSPOL = 0,
    .ui8WriteThreshold = 4,
    .ui8ReadThreshold = 60,
};

void drv_lcd_enable(void)
{
	DRV_LCD_LOG_PRINTF("[drv_lcd]: drv_lcd_enable\n");
	//xSemaphoreTake( Appolo_SPI_Semaphore, portMAX_DELAY );
	
	// Enable IOM
	bsp_iom_enable(BSP_LCD_IOM,g_sLCD_IOMConfig);
	
	am_hal_gpio_pin_config(BSP_GPIO_LCD_LSA0,AM_HAL_GPIO_OUTPUT);	//SA0
	// Enable LCD chip select
	am_hal_gpio_pin_config(BSP_GPIO_LCD_CE,BSP_GPIO_CFG_LCD_CE);
}

void drv_lcd_disable(void)
{
	DRV_LCD_LOG_PRINTF("[drv_lcd]: drv_lcd_disable\n");
	
	// Disable lcd chip select
	am_hal_gpio_pin_config(BSP_GPIO_LCD_CE,AM_HAL_GPIO_INPUT|AM_HAL_GPIO_PULLUP);
	
	am_hal_gpio_pin_config(BSP_GPIO_LCD_LSA0,AM_HAL_GPIO_INPUT|AM_HAL_GPIO_PULLUP);
	
	// Disable IOM
	bsp_iom_disable(BSP_LCD_IOM);

	//xSemaphoreGive( Appolo_SPI_Semaphore );	
}

void drv_lcd_read(uint32_t *pui32Data, uint32_t ui32NumBytes)
{
	drv_lcd_enable();
	
	am_hal_iom_spi_read(BSP_LCD_IOM, BSP_LCD_CS,
							pui32Data, ui32NumBytes, AM_HAL_IOM_RAW);
	
	drv_lcd_disable();
	
}

void drv_lcd_ctrl_write(uint8_t pui32Data)
{
	am_hal_iom_buffer(1) sData = {0};
	sData.bytes[0] = pui32Data;
	//drv_lcd_enable();
	am_hal_gpio_out_bit_clear(BSP_GPIO_LCD_LSA0);
	am_hal_iom_spi_write(BSP_LCD_IOM, BSP_LCD_CS,
							sData.words, 1, AM_HAL_IOM_RAW);
	
	//drv_lcd_disable();
	
}


void drv_lcd_data_write(uint8_t pui32Data)
{
	am_hal_iom_buffer(1) sData = {0};
	sData.bytes[0] = pui32Data;
	//drv_lcd_enable();
	am_hal_gpio_out_bit_set(BSP_GPIO_LCD_LSA0);
	am_hal_iom_spi_write(BSP_LCD_IOM, BSP_LCD_CS,
							sData.words, 1, AM_HAL_IOM_RAW);
	
	//drv_lcd_disable();
	
}





void drv_lcd_block_data_write(uint32_t *pui32Data, uint32_t ui32NumBytes)
{
	//drv_lcd_enable();
	am_hal_gpio_out_bit_set(BSP_GPIO_LCD_LSA0);
	am_hal_iom_spi_write(BSP_LCD_IOM, BSP_LCD_CS,
							pui32Data, ui32NumBytes, AM_HAL_IOM_RAW);
	
	//drv_lcd_disable();
	
}

void drv_lcd_switch_hpm_to_lpm(void)
{
   if(mp_flag == 0)
   	{
		return;
    }
   
	//if (light_enable == 0)
	{
		//drv_lcd_ctrl_write(0x38);   // //High Power Mode ON 
	
		drv_lcd_ctrl_write(0xc0);   //                       
		drv_lcd_data_write(0X86);
		drv_lcd_ctrl_write(0xD6);   //                     
		drv_lcd_data_write(0X01);  // 
		am_util_delay_ms(100);
	
		drv_lcd_ctrl_write(0x39);   // Low Power Mode ON
		am_util_delay_ms(50);
		mp_flag = 0;
	}

}

void drv_lcd_switch_lpm_to_hpm(void)
{ 
	if(mp_flag == 1)
   	{
		return;
    }
	//if (light_enable == 0)
	{
		//drv_lcd_ctrl_write(0x39);   // Low Power Mode ON

		drv_lcd_ctrl_write(0x38);   // //High Power Mode ON 
		am_util_delay_ms(300);
	
		drv_lcd_ctrl_write(0xc0);   //                       
		drv_lcd_data_write(0X4A);
		drv_lcd_ctrl_write(0xD6);   //                     
		drv_lcd_data_write(0X02);  //    
		
		am_util_delay_ms(100);
		mp_flag =1;
	}

}

#ifdef WATXCH_LCD_TRULY

uint8_t truly_lcd_flag = 0;

extern uint8_t task_start_flag;
uint64_t te_count = 0;
static void te_int_handle(void)
{
	te_count++;	
	
}

static void drv_lcd_te_irq_init(void)
{
	am_hal_gpio_int_register(BSP_GPIO_LCD_TE, te_int_handle);
	am_hal_gpio_pin_config(BSP_GPIO_LCD_TE,AM_HAL_GPIO_INPUT);
	am_hal_gpio_int_polarity_bit_set(BSP_GPIO_LCD_TE,AM_HAL_GPIO_RISING);
	am_hal_gpio_int_clear(AM_HAL_GPIO_BIT(BSP_GPIO_LCD_TE));
	
	am_hal_gpio_int_enable(AM_HAL_GPIO_BIT(BSP_GPIO_LCD_TE));

	am_util_delay_ms(5);;

}

void drv_lcd_te_irq_disable(void)
{

	am_hal_gpio_int_disable(AM_HAL_GPIO_BIT(BSP_GPIO_LCD_TE));

}

void drv_lcd_te_irq_enable(void)
{
	am_hal_gpio_int_enable(AM_HAL_GPIO_BIT(BSP_GPIO_LCD_TE));

}


//判断是否有te信号
uint8_t whether_lcd_te_high(void)
{
	uint64_t tmp_count= 0;
	uint16_t cycle_index = 0;
	uint8_t ret = 0;
	tmp_count = te_count;
	
	while ((te_count <= tmp_count)&&(cycle_index < 200))
	{	
		vTaskDelay(1);
		cycle_index++;		
	}
	DRV_LCD_LOG_PRINTF("whether_lcd_te_high %d\r\n",cycle_index);
	if (te_count > tmp_count)
	{
		DRV_LCD_LOG_PRINTF("cd_te_is_high\r\n");
		ret = 1;
	}

	return ret;
}

#endif


#endif


#ifdef WATCH_COD_BSP 
#else

static void LCD_PWM_Init(void)
{
	am_hal_gpio_pin_config(BSP_GPIO_LCD_XFRP,BSP_GPIO_CFG_LCD_XFRP);
	am_hal_gpio_pin_config(BSP_GPIO_LCD_VCOM,BSP_GPIO_CFG_LCD_VCOM);
	
	//A1,频率为60Hz
    am_hal_ctimer_config_single(BSP_LCD_XFRP_CTIMER_NUM, BSP_LCD_XFRF_CTIMER_SEGMENT,
                                (AM_HAL_CTIMER_FN_PWM_REPEAT |
                                 AM_HAL_CTIMER_LFRC_512HZ |
                                 AM_HAL_CTIMER_PIN_ENABLE));
    am_hal_ctimer_period_set(BSP_LCD_XFRP_CTIMER_NUM, BSP_LCD_XFRF_CTIMER_SEGMENT, 8, 4);
    am_hal_ctimer_start(BSP_LCD_XFRP_CTIMER_NUM, BSP_LCD_XFRF_CTIMER_SEGMENT);
	
	//B1,频率为反向60Hz
	am_hal_ctimer_config_single(BSP_LCD_VCOM_CTIMER_NUM, BSP_LCD_VCOM_CTIMER_SEGMENT,
                                (AM_HAL_CTIMER_FN_PWM_REPEAT |
                                 AM_HAL_CTIMER_LFRC_512HZ |
								 AM_HAL_CTIMER_PIN_INVERT |
                                 AM_HAL_CTIMER_PIN_ENABLE));
    am_hal_ctimer_period_set(BSP_LCD_VCOM_CTIMER_NUM, BSP_LCD_VCOM_CTIMER_SEGMENT, 8, 4);
    am_hal_ctimer_start(BSP_LCD_VCOM_CTIMER_NUM, BSP_LCD_VCOM_CTIMER_SEGMENT);
}
#endif
void LCD_Poweron(void)
{	
#ifdef WATCH_COD_BSP 
		am_hal_gpio_pin_config(BSP_GPIO_LCD_PWR,AM_HAL_GPIO_OUTPUT);
		am_hal_gpio_out_bit_set(BSP_GPIO_LCD_PWR);
		am_util_delay_ms(5);
#else

	//VDD1
	am_hal_gpio_pin_config(BSP_GPIO_LCD_VDD1,AM_HAL_GPIO_OUTPUT);
	LCD_VDD1_HIGH();
	am_util_delay_ms(1);
	
	//VDD2
	am_hal_gpio_pin_config(BSP_GPIO_LCD_VDD2,AM_HAL_GPIO_OUTPUT);
	LCD_VDD2_HIGH();
	am_util_delay_ms(5);
#endif
}

void LCD_Poweroff(void)
{
#ifdef WATCH_COD_BSP 
		am_hal_gpio_out_bit_clear(BSP_GPIO_LCD_PWR);
#else
	LCD_DisplayOff();
	
	//VDD2
	LCD_VDD2_LOW();
	am_util_delay_ms(1);
	
	//VDD1
	LCD_VDD1_LOW();
	am_util_delay_ms(1);
#endif
}

void LCD_DisplayOn(void)
{
#ifdef WATCH_COD_BSP 
#else

	am_util_delay_ms(1);
	
	LCD_PWM_Init();
	am_util_delay_ms(1);
#endif
}

void LCD_DisplayOff(void)
{	
#ifdef WATCH_COD_BSP 
#else

	//停止输出64HZ
	am_hal_ctimer_stop(BSP_LCD_XFRP_CTIMER_NUM, BSP_LCD_XFRF_CTIMER_SEGMENT);
	am_hal_ctimer_stop(BSP_LCD_VCOM_CTIMER_NUM, BSP_LCD_VCOM_CTIMER_SEGMENT);
	
//	am_hal_gpio_pin_config(BSP_GPIO_LCD_XFRP,AM_HAL_GPIO_3STATE);
//	am_hal_gpio_pin_config(BSP_GPIO_LCD_VCOM,AM_HAL_GPIO_3STATE);
	am_hal_gpio_pin_config(BSP_GPIO_LCD_XFRP,AM_HAL_GPIO_OUTPUT);
	am_hal_gpio_out_bit_clear(BSP_GPIO_LCD_XFRP);
	
	am_hal_gpio_pin_config(BSP_GPIO_LCD_VCOM,AM_HAL_GPIO_OUTPUT);
	am_hal_gpio_out_bit_clear(BSP_GPIO_LCD_VCOM);
	
	am_util_delay_ms(5);
#endif
}
#ifdef WATCH_COD_BSP 

//屏复位
void drv_lcd_reset(void)
{
	am_hal_gpio_out_bit_set(BSP_GPIO_LCD_REST);
	am_util_delay_ms(20);
	am_hal_gpio_out_bit_clear(BSP_GPIO_LCD_REST);
	am_util_delay_ms(20);
	am_hal_gpio_out_bit_set(BSP_GPIO_LCD_REST);
	am_util_delay_ms(100);

}


//屏放电
void drv_lcd_discharge(void)
{
	drv_lcd_enable();
	drv_lcd_ctrl_write(0x28);//display off 
	drv_lcd_disable();
	am_util_delay_ms(100); 
	drv_lcd_enable();
	drv_lcd_ctrl_write(0x10);//power off
	drv_lcd_disable();
	am_util_delay_ms(100); 

}
#endif

void LCD_Init(void)
{
#ifdef WATCH_COD_BSP 
		//am_hal_gpio_pin_config(BSP_GPIO_LCD_LSA0,AM_HAL_GPIO_OUTPUT); //SA0
		am_hal_gpio_pin_config(BSP_GPIO_LCD_REST,AM_HAL_GPIO_OUTPUT);	//REST
	
		drv_lcd_reset();
		drv_lcd_discharge();
#ifdef WATXCH_LCD_TRULY
	drv_lcd_enable();
	drv_lcd_ctrl_write(0xEB);   //Enable OTP
    drv_lcd_data_write(0X02);  // SCYS[7:6], WRCYC[5:3], DSCYC[2:0]
    drv_lcd_ctrl_write(0xD7);   //OTP Load Control
    drv_lcd_data_write(0X68);  //

    drv_lcd_ctrl_write(0xD1);   //Auto Power Control
    drv_lcd_data_write(0X01);  // 
		
	drv_lcd_ctrl_write(0x35);   //TE ON
    drv_lcd_data_write(0X00);  //
	drv_lcd_ctrl_write(0x38);//HPM
	drv_lcd_ctrl_write(0x11);   //Sleep out 
    //am_util_delay_ms(100);
	drv_lcd_disable();

	drv_lcd_te_irq_init();

	truly_lcd_flag = whether_lcd_te_high();
	//8hz
	drv_lcd_enable();
	if(truly_lcd_flag) //truly_lcd
	{
	  drv_lcd_ctrl_write(0xEB);   //Enable OTP
	  drv_lcd_data_write(0X02);  // SCYS[7:6], WRCYC[5:3], DSCYC[2:0]
	  drv_lcd_ctrl_write(0xD7);   //OTP Load Control
	  drv_lcd_data_write(0X68);  //
	 
	  drv_lcd_ctrl_write(0xD1);   //Auto Power Control
	  drv_lcd_data_write(0X01);  //
	 
	  drv_lcd_ctrl_write(0xC0);
	  drv_lcd_data_write(0XE6);//VGH=15V; VGL=-8V
	 
	  drv_lcd_ctrl_write(0xC1);//VSH=5V
	  drv_lcd_data_write(0X28);
	  drv_lcd_data_write(0X28);
	  drv_lcd_data_write(0X28);
	  drv_lcd_data_write(0X28);
	  drv_lcd_data_write(0X13);
	  drv_lcd_data_write(0X12);
	  
	  drv_lcd_ctrl_write(0xC2);//VSL=1.45V
	  drv_lcd_data_write(0X0D);
	  drv_lcd_data_write(0X0D);
	  drv_lcd_data_write(0X0D);
	  drv_lcd_data_write(0X0D);
	 
	  drv_lcd_ctrl_write(0xCB);//VCOMH=4.45V
	  drv_lcd_data_write(0X20);
	 
	  //drv_lcd_ctrl_write(0xB2);//FR
	 // drv_lcd_data_write(0X00);//16Hz
	 // drv_lcd_data_write(0X02);//1Hz
	  //drv_lcd_ctrl_write(0x38);//HPM
	 
	  drv_lcd_ctrl_write(0xB4);//Gate EQ
	  drv_lcd_data_write(0XA5);
	  drv_lcd_data_write(0X66);
	  drv_lcd_data_write(0XFD);
	  drv_lcd_data_write(0XBF);
	  drv_lcd_data_write(0X42);
	  drv_lcd_data_write(0X55);
	  drv_lcd_data_write(0X81);
	  drv_lcd_data_write(0XBE);
	  drv_lcd_data_write(0X42);
	  drv_lcd_data_write(0X55);
	 
	  drv_lcd_ctrl_write(0xB7);//SOURCE EQ
	  drv_lcd_data_write(0x01);
	 
	  drv_lcd_ctrl_write(0xB0);//Gate line setting
	  drv_lcd_data_write(0x78);//480line
	  
	  
	   drv_lcd_ctrl_write(0x11);//slp-out
	   am_util_delay_ms(100);
	  
	  drv_lcd_ctrl_write(0xC7);//osc
	  drv_lcd_data_write(0XA6);//
	  drv_lcd_data_write(0XE9);
	  drv_lcd_data_write(0XCA);//
	  drv_lcd_data_write(0X77);
	  
	  drv_lcd_ctrl_write(0xB2);
	  drv_lcd_data_write(0X00);//16Hz
	  drv_lcd_data_write(0X05);//8Hz
	  //drv_lcd_ctrl_write(0x38);//选择高频模式
	  
	 
	 // drv_lcd_ctrl_write(0x38);//选择高频模式
	 
	  drv_lcd_ctrl_write(0xD6);//soruce vol. setting
	  drv_lcd_data_write(0x00);
	 
	  drv_lcd_ctrl_write(0x36);
	  drv_lcd_data_write(0x04);
	 
	  drv_lcd_ctrl_write(0x3A);
	  drv_lcd_data_write(0x10);
	 
	  drv_lcd_ctrl_write(0x72);//gate timing
	  drv_lcd_data_write(0x33);
	  drv_lcd_data_write(0x03);
	  drv_lcd_data_write(0x1F);
	  drv_lcd_data_write(0x23);
	 
	  drv_lcd_ctrl_write(0xB9);//source setting
	  drv_lcd_data_write(0x23);
	 
	  drv_lcd_ctrl_write(0xB8);//panel setting
	  drv_lcd_data_write(0x08);//2 line interlace, 2 line panel layout
	 
	  drv_lcd_ctrl_write(0x2A);//column address
	  drv_lcd_data_write(0x00);
	  drv_lcd_data_write(0x3B);
	  drv_lcd_ctrl_write(0x2B);//row address
	  drv_lcd_data_write(0x00);
	  drv_lcd_data_write(0xEF);
	 
	  drv_lcd_ctrl_write(0x35);
	  drv_lcd_data_write(0x00);
	 
	  drv_lcd_ctrl_write(0xD0);//auto power down
	  drv_lcd_data_write(0x1F);
	 
	 
	  drv_lcd_ctrl_write(0xD8);//high voltage setting
	  drv_lcd_data_write(0x01);
	 
	  drv_lcd_ctrl_write(0x39);

	}
	else //GP lcd
	{
		drv_lcd_enable();
		drv_lcd_ctrl_write(0xEB);	//Enable OTP									  
		drv_lcd_data_write(0X02);  // SCYS[7:6], WRCYC[5:3], DSCYC[2:0] 			
		drv_lcd_ctrl_write(0xD7);	//OTP Load Control								  
		drv_lcd_data_write(0X68);  //												
													 
		drv_lcd_ctrl_write(0xD1);	//Auto Power Control							  
		drv_lcd_data_write(0X01);  //
		
		drv_lcd_ctrl_write(0xe8);	//					   
		drv_lcd_data_write(0X55);  //									  
		drv_lcd_data_write(0X06);  //												 
	
		drv_lcd_ctrl_write(0xC0);	//Gate Voltage Setting							  
		drv_lcd_data_write(0X4A);  //VGH=10V ; VGL=-8V
	
		drv_lcd_ctrl_write(0xC1);	//VSH Setting						   
		drv_lcd_data_write(0X1D);  //VSH_HPM_R=5V										
		drv_lcd_data_write(0X1D);  //VSH_HPM_T=5V									 
		drv_lcd_data_write(0X1B);  //VSH_LPM_R										
		drv_lcd_data_write(0X1B);  //VSH_LPM_T	
	
	
		drv_lcd_ctrl_write(0xC2);	//VSL Setting						   
		drv_lcd_data_write(0X09);  //VSH_HPM_R=1V										
		drv_lcd_data_write(0X09);  //VSH_HPM_T=1V									 
		drv_lcd_data_write(0X0B);  //VSH_LPM_R=1V									   
		drv_lcd_data_write(0X0B);  //VSH_LPM_T=1V  
	
		drv_lcd_ctrl_write(0xCB);	 //VCOMH SETTING						 
		drv_lcd_data_write(0X14);  //VCOMH=4.4V 
	
		drv_lcd_ctrl_write(0xC4);	 // 					   
		drv_lcd_data_write(0Xb1);  //
	
		drv_lcd_ctrl_write(0xB4);	//Gate EQ										  
		drv_lcd_data_write(0XE5);  //												
		drv_lcd_data_write(0Xaa);  //												
		drv_lcd_data_write(0Xe0);  //HPM EQ 
		drv_lcd_data_write(0XFF);  //										   
		drv_lcd_data_write(0XFF);  //												
		drv_lcd_data_write(0X0b);  //												
		drv_lcd_data_write(0Xe1);  //												
		drv_lcd_data_write(0XFF);  //LPM EQ 										
		drv_lcd_data_write(0XFF);  //												
		drv_lcd_data_write(0X52);  //	
		
		drv_lcd_ctrl_write(0xB7);	//									 
		drv_lcd_data_write(0X01);													
		drv_lcd_data_write(0X03);  
		
		drv_lcd_ctrl_write(0x71);	//									 
		drv_lcd_data_write(0X00);													
		drv_lcd_data_write(0X03);  
		drv_lcd_data_write(0X1F);													
		drv_lcd_data_write(0X33);											   
	 
		drv_lcd_ctrl_write(0x72);	//									 
		drv_lcd_data_write(0X00);													
		drv_lcd_data_write(0X03);  
		drv_lcd_data_write(0X1F);													
		drv_lcd_data_write(0X33);	
	
		drv_lcd_ctrl_write(0x73);	//									 
		drv_lcd_data_write(0X00);													
		drv_lcd_data_write(0X03);  
		drv_lcd_data_write(0X1F);													
		drv_lcd_data_write(0X33);  
		
		drv_lcd_ctrl_write(0x74);	//									 
		drv_lcd_data_write(0X00);													
		drv_lcd_data_write(0X03);  
		drv_lcd_data_write(0X1F);													
		drv_lcd_data_write(0X33); 
		
		drv_lcd_ctrl_write(0x75);	//									 
		drv_lcd_data_write(0X20);		  
	
		drv_lcd_ctrl_write(0x11);	//Sleep out 									  
		am_util_delay_ms(120);	
		
		drv_lcd_ctrl_write(0xD0);	//									 
		drv_lcd_data_write(0X1F);		
	
		
		drv_lcd_ctrl_write(0xD6);	//									 
		drv_lcd_data_write(0X02);		
	
		drv_lcd_ctrl_write(0xC7);	//OSC Setting									  
		drv_lcd_data_write(0X80);
		drv_lcd_data_write(0XE9); 
		
		drv_lcd_ctrl_write(0x35);
																													
		drv_lcd_ctrl_write(0x36);	//MY=0, MX=0, MV=0, ML=0						  
		drv_lcd_data_write(0x04);	// MX=0 ; DO=0	 
								   
		drv_lcd_ctrl_write(0x3A);	//64Color Mode									  
		drv_lcd_data_write(0X00);  //00:4write for 24bit ; 01: 3write for 24bit  
		
		drv_lcd_ctrl_write(0xBD);	//								  
		drv_lcd_data_write(0X01);  //	   
									
		drv_lcd_ctrl_write(0xB9);	//Source Setting								  
		drv_lcd_data_write(0X23);  //Pixel Cutting	  
									  
		drv_lcd_ctrl_write(0xB8);	//Source Setting								  
		drv_lcd_data_write(0X08);  //Pixel Cutting																		 
	
		drv_lcd_ctrl_write(0x38);	//LPM 0x39,HPM 0x38
	}
#else	
		drv_lcd_enable();
		drv_lcd_ctrl_write(0xEB);	//Enable OTP									  
		drv_lcd_data_write(0X02);  // SCYS[7:6], WRCYC[5:3], DSCYC[2:0] 			
		drv_lcd_ctrl_write(0xD7);	//OTP Load Control								  
		drv_lcd_data_write(0X68);  //												
													 
		drv_lcd_ctrl_write(0xD1);	//Auto Power Control							  
		drv_lcd_data_write(0X01);  //
		
		drv_lcd_ctrl_write(0xe8);	//					   
		drv_lcd_data_write(0X55);  //									  
		drv_lcd_data_write(0X06);  //												 
	
		drv_lcd_ctrl_write(0xC0);	//Gate Voltage Setting							  
		drv_lcd_data_write(0X4A);  //VGH=10V ; VGL=-8V
	
		drv_lcd_ctrl_write(0xC1);	//VSH Setting						   
		drv_lcd_data_write(0X1D);  //VSH_HPM_R=5V										
		drv_lcd_data_write(0X1D);  //VSH_HPM_T=5V									 
		drv_lcd_data_write(0X1B);  //VSH_LPM_R										
		drv_lcd_data_write(0X1B);  //VSH_LPM_T	
	
	
		drv_lcd_ctrl_write(0xC2);	//VSL Setting						   
		drv_lcd_data_write(0X09);  //VSH_HPM_R=1V										
		drv_lcd_data_write(0X09);  //VSH_HPM_T=1V									 
		drv_lcd_data_write(0X0B);  //VSH_LPM_R=1V									   
		drv_lcd_data_write(0X0B);  //VSH_LPM_T=1V  
	
		drv_lcd_ctrl_write(0xCB);	 //VCOMH SETTING						 
		drv_lcd_data_write(0X14);  //VCOMH=4.4V 
	
		drv_lcd_ctrl_write(0xC4);	 // 					   
		drv_lcd_data_write(0Xb1);  //
	
		drv_lcd_ctrl_write(0xB4);	//Gate EQ										  
		drv_lcd_data_write(0XE5);  //												
		drv_lcd_data_write(0Xaa);  //												
		drv_lcd_data_write(0Xe0);  //HPM EQ 
		drv_lcd_data_write(0XFF);  //										   
		drv_lcd_data_write(0XFF);  //												
		drv_lcd_data_write(0X0b);  //												
		drv_lcd_data_write(0Xe1);  //												
		drv_lcd_data_write(0XFF);  //LPM EQ 										
		drv_lcd_data_write(0XFF);  //												
		drv_lcd_data_write(0X52);  //	
		
		drv_lcd_ctrl_write(0xB7);	//									 
		drv_lcd_data_write(0X01);													
		drv_lcd_data_write(0X03);  
		
		drv_lcd_ctrl_write(0x71);	//									 
		drv_lcd_data_write(0X00);													
		drv_lcd_data_write(0X03);  
		drv_lcd_data_write(0X1F);													
		drv_lcd_data_write(0X33);											   
	 
		drv_lcd_ctrl_write(0x72);	//									 
		drv_lcd_data_write(0X00);													
		drv_lcd_data_write(0X03);  
		drv_lcd_data_write(0X1F);													
		drv_lcd_data_write(0X33);	
	
		drv_lcd_ctrl_write(0x73);	//									 
		drv_lcd_data_write(0X00);													
		drv_lcd_data_write(0X03);  
		drv_lcd_data_write(0X1F);													
		drv_lcd_data_write(0X33);  
		
		drv_lcd_ctrl_write(0x74);	//									 
		drv_lcd_data_write(0X00);													
		drv_lcd_data_write(0X03);  
		drv_lcd_data_write(0X1F);													
		drv_lcd_data_write(0X33); 
		
		drv_lcd_ctrl_write(0x75);	//									 
		drv_lcd_data_write(0X20);		  
	
		drv_lcd_ctrl_write(0x11);	//Sleep out 									  
		am_util_delay_ms(120);	
		
		drv_lcd_ctrl_write(0xD0);	//									 
		drv_lcd_data_write(0X1F);		
	
		
		drv_lcd_ctrl_write(0xD6);	//									 
		drv_lcd_data_write(0X02);		
	
		drv_lcd_ctrl_write(0xC7);	//OSC Setting									  
		drv_lcd_data_write(0X80);
		drv_lcd_data_write(0XE9); 
		
		drv_lcd_ctrl_write(0x35);
																													
		drv_lcd_ctrl_write(0x36);	//MY=0, MX=0, MV=0, ML=0						  
		drv_lcd_data_write(0x04);	// MX=0 ; DO=0	 
								   
		drv_lcd_ctrl_write(0x3A);	//64Color Mode									  
		drv_lcd_data_write(0X00);  //00:4write for 24bit ; 01: 3write for 24bit  
		
		drv_lcd_ctrl_write(0xBD);	//								  
		drv_lcd_data_write(0X01);  //	   
									
		drv_lcd_ctrl_write(0xB9);	//Source Setting								  
		drv_lcd_data_write(0X23);  //Pixel Cutting	  
									  
		drv_lcd_ctrl_write(0xB8);	//Source Setting								  
		drv_lcd_data_write(0X08);  //Pixel Cutting																		 
	
		drv_lcd_ctrl_write(0x38);	//LPM 0x39,HPM 0x38
		#endif
		mp_flag = 1;
		drv_lcd_disable();
		
		LCD_SetBackgroundColor(LCD_BLACK);
		LCD_DisplaySomeLine(0,LCD_LINE_CNT_MAX);
		
		drv_lcd_enable();
		drv_lcd_ctrl_write(0x29);	//DISPLAY ON 
		drv_lcd_disable();
		
		am_util_delay_ms(100); 
	
		//LCD_SetBackgroundColor(LCD_BLACK);
		
		//drv_lcd_ctrl_write(0x2C);  
		
		
#else

	am_hal_gpio_pin_config(BSP_GPIO_LCD_XRST,AM_HAL_GPIO_OUTPUT);	//XRST
	am_hal_gpio_pin_config(BSP_GPIO_LCD_ENB,AM_HAL_GPIO_OUTPUT);	//ENB
	am_hal_gpio_pin_config(BSP_GPIO_LCD_B1,AM_HAL_GPIO_OUTPUT);		//B1
	am_hal_gpio_pin_config(BSP_GPIO_LCD_G1,AM_HAL_GPIO_OUTPUT);		//G1
	am_hal_gpio_pin_config(BSP_GPIO_LCD_R1,AM_HAL_GPIO_OUTPUT);		//R1
	am_hal_gpio_pin_config(BSP_GPIO_LCD_HST,AM_HAL_GPIO_OUTPUT);	//HST
	am_hal_gpio_pin_config(BSP_GPIO_LCD_VCK,AM_HAL_GPIO_OUTPUT);	//VCK
	am_hal_gpio_pin_config(BSP_GPIO_LCD_VST,AM_HAL_GPIO_OUTPUT);	//VST
	am_hal_gpio_pin_config(BSP_GPIO_LCD_HCK,AM_HAL_GPIO_OUTPUT);	//HCK
	am_hal_gpio_pin_config(BSP_GPIO_LCD_B0,AM_HAL_GPIO_OUTPUT);		//B0
	am_hal_gpio_pin_config(BSP_GPIO_LCD_G0,AM_HAL_GPIO_OUTPUT);		//G0
	am_hal_gpio_pin_config(BSP_GPIO_LCD_R0,AM_HAL_GPIO_OUTPUT);		//R0	
	
	LCD_XRST_LOW();
	LCD_ENB_LOW();
	LCD_BLUE1_LOW();
	LCD_GREEN1_LOW();
	LCD_RED1_LOW();
	LCD_HST_LOW();
	LCD_VCK_LOW();
	LCD_VST_LOW();
	LCD_HCK_LOW();
	LCD_BLUE0_LOW();
	LCD_GREEN0_LOW();
	LCD_RED0_LOW();
	
	am_hal_gpio_pin_config(BSP_GPIO_LCD_XFRP,AM_HAL_GPIO_OUTPUT);
	am_hal_gpio_out_bit_clear(BSP_GPIO_LCD_XFRP);
	
	am_hal_gpio_pin_config(BSP_GPIO_LCD_VCOM,AM_HAL_GPIO_OUTPUT);
	am_hal_gpio_out_bit_clear(BSP_GPIO_LCD_VCOM);
#endif
}
#ifdef WATCH_COD_BSP 
#else

static void LCD_InvertVck(void)
{
	//Toggle VCK
	am_hal_gpio_out_bit_toggle(BSP_GPIO_LCD_VCK);
}

static void LCD_InvertHck(void)
{
	//Toggle HCK
	am_hal_gpio_out_bit_toggle(BSP_GPIO_LCD_HCK);
}

static void LCD_InvertEnb(void)
{
	//Toggle ENB
	am_hal_gpio_out_bit_toggle(BSP_GPIO_LCD_ENB);
}

static void LCD_SetRGB(uint8_t data)
{
	AM_REGn(GPIO, 0, WTA) = (AM_REGn(GPIO, 0, WTA) & 0xFFFE23FF) | (data<<10);
}

static void LCD_SetDataInHorizontal(uint16_t line,uint8_t *pixelBuf)
{
	uint16_t pixelCntInLine;
	uint8_t pixel1,pixel2,pixelData;
	
//	if(((uint32_t *)pixelBuf > (uint32_t *)0x10010000) 
//		|| ((uint32_t *)pixelBuf < (uint32_t *)0x10000000))
//	{
//		//刷屏指针指飞，重启手表
//		
//#ifdef ERROR_CODE		
//			LCD_Error_Code(10,0);
//#endif		
//		
//		return;
//	}

	LCD_InvertVck(); 
//	am_util_delay_us(37);
	LCD_HST_HIGH();
	
//	am_util_delay_us(1);//0.34us
	LCD_InvertHck();
	
//	am_util_delay_us(1);//0.34us
//	LCD_InvertHck();

//	am_util_delay_us(1);//0.34us
	LCD_HST_LOW();
	
	for (pixelCntInLine = 0; pixelCntInLine < (LCD_LINE_CNT_MAX/2); ) 
	{
		pixel1 = *pixelBuf;
		pixelBuf--;
		pixel2 = *pixelBuf;
		pixelBuf--;
		if(line%2 != 1)
		{
			pixelData = ((pixel1&0x07)<<4)|(pixel2&0x07);
		}
		else
		{
			pixelData = (pixel1&0x70)|((pixel2&0x70)>>4);
		}
		LCD_SetRGB(pixelData);          /**< set RGB data, even + odd   */

//		am_util_delay_us(1);//0.34us;
		LCD_InvertHck();                          /**< invert HCK                 */
		
//		am_util_delay_us(1);//0.34us;
		pixelCntInLine++;
		
		pixel1 = *pixelBuf;
		pixelBuf--;
		pixel2 = *pixelBuf;
		pixelBuf--;
		if(line%2 != 1)
		{
			pixelData = ((pixel1&0x07)<<4)|(pixel2&0x07);
		}
		else
		{
			pixelData = (pixel1&0x70)|((pixel2&0x70)>>4);
		}
		LCD_SetRGB(pixelData);          /**< set RGB data, even + odd   */

//		am_util_delay_us(1);//0.34us;
		LCD_InvertHck();                          /**< invert HCK                 */
		
//		am_util_delay_us(1);//0.34us;
		pixelCntInLine++;
		if(m_enableEnb)
		{
			if(pixelCntInLine == 4||pixelCntInLine == 104)
			{
				LCD_InvertEnb();
			}
		}
	}
	LCD_SetRGB(0x00); 
//	am_util_delay_us(1);//0.68us
//	LCD_InvertHck();
//	am_util_delay_us(1);//0.68us
	LCD_InvertHck();
	
	m_enableEnb = false;
}
#endif
/**
  * @brief  Update the panel with image from display buffer
  * @param  starline:  Starting line number (0-239).
  * @param  len:  line length (<=240)
  * @retval
  */
void LCD_DisplaySomeLine(uint16_t starline,uint16_t len)
{
#ifdef WATCH_COD_BSP  
		uint16_t endline = starline + len -1;
		uint16_t tmpline;
		
		for (tmpline = starline ;tmpline <= endline ;tmpline++)
		{
			for(uint8_t i= 0;i < LCD_PIXEL_ONELINE_MAX;i++)
			{
			g_dispBuf[tmpline][i] = ((g_dispBuf[tmpline][i] & 0x40) >>3) |(g_dispBuf[tmpline][i] &0x04) | ((g_dispBuf[tmpline][i] &0x02) << 3) 
					|((g_dispBuf[tmpline][i] &0x20))| ((g_dispBuf[tmpline][i] &0x10)<<3)| ((g_dispBuf[tmpline][i] &0x01)<< 6);
			}
		}
		drv_lcd_enable();
		drv_lcd_ctrl_write(0x2a);		// Column Address Set
		drv_lcd_data_write(0x00);		// 
		drv_lcd_data_write(0x3b);		
		
		drv_lcd_ctrl_write(0x2b);		// Row Address Set
		drv_lcd_data_write(starline);		// 
		drv_lcd_data_write(endline);		// 
		
	
		//drv_lcd_switch_lpm_to_hpm();
		
	
		
		drv_lcd_ctrl_write(0x2c);
	
		
		for (tmpline = starline ;tmpline <= endline ;tmpline++)
		{
 		
			drv_lcd_block_data_write((uint32_t *)g_dispBuf[tmpline],LCD_PIXEL_ONELINE_MAX); 
		}
	
		//DRV_LCD_LOG_PRINTF("g_dispBuf  = %x\r\n",g_dispBuf[120][120]);
		
		//drv_lcd_switch_hpm_to_lpm();
		drv_lcd_disable();
		//timer_lcd_start();
	
#else

	int16_t i;
	m_enableEnb = false;
	
	LCD_XRST_LOW();
	LCD_VST_LOW();
	LCD_VCK_LOW();
	LCD_HST_LOW();
	LCD_HCK_LOW();
	LCD_ENB_LOW();
	LCD_SetRGB(0);
	
	am_util_delay_us(10);//10.2us
	
	LCD_XRST_HIGH(); 
	am_util_delay_us(1);//0.68us
	
	LCD_VST_HIGH();
//	am_util_delay_us(1);//0.34us
	LCD_InvertVck();
	am_util_delay_us(1);
	LCD_VST_LOW();                         /**< set low level on VST. Except the first line, keep "L" level    */
//	am_util_delay_us(75);//75.38us
	
	for(i = (LCD_LINE_CNT_MAX*2 - 1);i >= 0;)
	{	
		if((i>=(starline*2)) && (i<(starline*2+len*2)))
		{			
			LCD_SetDataInHorizontal(i,&g_dispBuf[i/2][LCD_PIXEL_ONELINE_MAX-1]);	
			m_enableEnb = true;
			i--;
			LCD_SetDataInHorizontal(i,&g_dispBuf[i/2][LCD_PIXEL_ONELINE_MAX-1]);
			m_enableEnb = true;
			i--;
		}
		else
		{
			LCD_InvertVck();
			i--;
			if(m_enableEnb)
			{
				m_enableEnb = false;
				LCD_InvertEnb();
				LCD_InvertEnb();
			}
			LCD_InvertVck();
			i--;
		}
	}

	LCD_InvertVck();                                  /**< set low level on VCK  */
//	am_util_delay_us(5);//5.36us
	if(m_enableEnb)
	{
		LCD_InvertEnb();                      /**< set high level on ENB  */
	//	am_util_delay_us(63);//63.32us-1689
		LCD_InvertEnb();                      /**< set low level on ENB   */
	//	am_util_delay_us(7);//6.7us-179
	}
	LCD_InvertVck();
//	am_util_delay_us(75);//75.38us-2010
	LCD_InvertVck();
	LCD_InvertVck();
//	am_util_delay_us(75);//75.38us-2010
	LCD_InvertVck();
	
	LCD_XRST_LOW();                /**< set low level on XRST  */
	LCD_InvertVck();
//	am_util_delay_us(75);//75.38us-2010
	LCD_InvertVck();
#endif
}

/**
  * @brief  Setting screen color
  * @param  color
  * @retval
  */
void LCD_SetBackgroundColor(uint8_t color)
{	
	memset(g_dispBuf, color, LCD_LINE_CNT_MAX*LCD_PIXEL_ONELINE_MAX);
}

static void line_draw(uint16_t x_0,
                      uint16_t y_0,
                      uint16_t x_1,
                      int16_t y_1,
                      uint32_t color)
{
    uint16_t x = x_0;
    uint16_t y = y_0;
    int16_t d;
    int16_t d_1;
    int16_t d_2;
    int16_t ai;
    int16_t bi;
    int16_t xi = (x_0 < x_1) ? 1 : (-1);
    int16_t yi = (y_0 < y_1) ? 1 : (-1);
    bool swapped = false;

    d_1 = abs(x_1 - x_0);
    d_2 = abs(y_1 - y_0);

    g_dispBuf[y][x] = color;

    if (d_1 < d_2)
    {
        d_1 = d_1 ^ d_2;
        d_2 = d_1 ^ d_2;
        d_1 = d_2 ^ d_1;
        swapped = true;
    }

    ai = (d_2 - d_1) * 2;
    bi = d_2 * 2;
    d = bi - d_1;

    while ((y != y_1) || (x != x_1))
    {
        if (d >= 0)
        {
            x += xi;
            y += yi;
            d += ai;
        }
        else
        {
            d += bi;
            if (swapped)
            {
                y += yi;
            }
            else
            {
                x += xi;
            }
        }
        g_dispBuf[y][x] = color;
    }
}

/**
  * @brief  Draw a line
  * @param  point1x: POINT1 X coordinate.
  * @param  point1y: POINT1 Y coordinate.
  * @param  point2x: POINT2 X coordinate.
  * @param  point2y: POINT2 Y coordinate.
  * @param  pencolor: pen color.
  * @param  thickness: line thickness.
  * @retval 
  */
void LCD_SetLine( uint16_t point1y, uint16_t point1x, uint16_t point2y, uint16_t point2x,
                         uint8_t pencolor, uint8_t thickness )
{
	uint16_t x_thick = 0;
    uint16_t y_thick = 0;

    if (abs(point1x - point2x) > abs(point1y -point2y))
    {
        y_thick = thickness;
    }
    else
    {
        x_thick = thickness;
    }
	
//	if ((point1x == point2x) || (point1y == point2y))
//	{
//		rect_draw(point1x,
//				point1y,
//				abs(point2x - point1x) + x_thick,
//				abs(point2y - point1y) + y_thick,
//				color);
//	}
//	else
    {
        if (x_thick > 0)
        {
            for (uint16_t i = 0; i < thickness; i++)
            {
                line_draw(point1x + i,
                          point1y,
                          point2x + i,
                          point2y,
                          pencolor);
            }
        }
        else if (y_thick > 0)
        {
            for (uint16_t i = 0; i < thickness; i++)
            {
                line_draw(point1x,
                          point1y + i,
                          point2x,
                          point2y + i,
                          pencolor);
            }
        }
//		else
//		{
//			line_draw(point1x + x_thick,
//						point1y + y_thick,
//                      point2x + x_thick,
//                      point2y + y_thick,
//                      pencolor);
//		}
    }
}

/**
  * @brief  Draw a rectangle
  * @param  tlcornerx: Top left corner X coordinate (0-239).
  * @param  height:  line length (<=240).
  * @param  tlcornery: Top left corner Y coordinate (0-239).
  * @param  width: column length (<=240).
  * @param  pencolor: pen color.
  * @param  hlinethick: horizontal line thickness.
  * @param  vlinethick: vertical line thickness.
  * @param  fillenable: Fill Enable.
  * @retval
  */
void LCD_SetRectangle( uint8_t tlcornerx, uint8_t height, uint8_t tlcornery, uint8_t width,
						uint8_t pencolor, uint8_t hlinethick, uint8_t vlinethick, uint8_t fillenable)
{
	uint8_t i;
	
	if((tlcornerx >= LCD_LINE_CNT_MAX) || (tlcornery >= LCD_PIXEL_ONELINE_MAX)
		|| (height > LCD_LINE_CNT_MAX) || (width > LCD_PIXEL_ONELINE_MAX))
	{
		return;
	}
	
	if((LCD_LINE_CNT_MAX - height) < tlcornerx)
	{
		//防止溢出
		height = LCD_LINE_CNT_MAX - tlcornerx;
	}
	
	if((LCD_PIXEL_ONELINE_MAX - width) < tlcornery)
	{
		//防止溢出
		width = LCD_PIXEL_ONELINE_MAX - tlcornery;
	}
	
	if(fillenable == LCD_FILL_ENABLE)
	{
		//填充矩形色块
		for(i = 0; i < height; i++)
		{
			memset(&g_dispBuf[tlcornerx + i][tlcornery],pencolor,width);
		}
	}
	else
	{	
		//防止超出边界
		hlinethick = ( hlinethick > height ) ? height : hlinethick;
		vlinethick = ( vlinethick > width ) ? width : vlinethick;
		
		for(i = 0; i < height; i++)
		{
			if((i < hlinethick) || (i >= (height - hlinethick)))
			{
				//矩形的上下两边线
				memset(&g_dispBuf[tlcornerx + i][tlcornery],pencolor,width);
			}
			else
			{
				//矩形的左右两边线
				memset(&g_dispBuf[tlcornerx + i][tlcornery],pencolor,vlinethick);
				memset(&g_dispBuf[tlcornerx + i][width - vlinethick + tlcornery],pencolor,vlinethick);
			}
		}
	}
}

/**
  * @brief  Draw a triangle (三点以顺时针方向排列)
  * @param  y1:  起点所在行
  * @param  x1:  起点所在列
  * @param  y2:  中点所在行
  * @param  x2:  中点所在列
  * @param  y3:  终点所在行
  * @param  x3:  终点所在列
  * @param  pencolor: pen color.
  * @param  linethick: line thickness.
  * @param  fillenable: Fill Enable.
  * @retval
  */
void LCD_SetTriangle(uint8_t y1, uint8_t x1, uint8_t y2, uint8_t x2, uint8_t y3, uint8_t x3,
						uint8_t pencolor, uint8_t linethick, uint8_t fillenable)
{
    // Bounding rectangle
	uint8_t maxx = x1>x2?(x1>x3?x1:x3):(x2>x3?x2:x3);
	uint8_t minx = x1<x2?(x1<x3?x1:x3):(x2<x3?x2:x3);
	uint8_t maxy = y1>y2?(y1>y3?y1:y3):(y2>y3?y2:y3);
	uint8_t miny = y1<y2?(y1<y3?y1:y3):(y2<y3?y2:y3);

	if(fillenable)
	{
		// Scan through bounding rectangle
		for(int y = miny; y < maxy; y++)
		{
			for(int x = minx; x < maxx; x++)
			{
				// When all half-space functions positive, pixel is in triangle
				if(((x1 - x) * (y2 - y) - (y1 - y) * (x2 - x) >= 0) &&
					((x2 - x) * (y3 - y) - (y2 - y) * (x3 - x) >= 0) &&
					((x1 - x) * (y3 - y) - (y1 - y) * (x3 - x) <= 0))
				{
					g_dispBuf[y][x] = pencolor;
				}
			}
		}
	}
	else
	{
		LCD_SetLine(y1, x1, y2, x2, pencolor, linethick);
		LCD_SetLine(y2, x2, y3, x3, pencolor, linethick);
		LCD_SetLine(y3, x3, y1, x1, pencolor, linethick);
	}
}

/**
  * @brief  Draw a polygon
  * @param  p: 多边形点坐标数组，顺时针旋转。(暂时只需要画四边形).
  * @param  pencolor: pen color.
  * @param  thickness: Circle thickness.
  * @param  fillenable: Fill Enable.
  * @retval
  */
void LCD_SetPolygon(uint8_t *p,	uint8_t pencolor, uint8_t linethick, uint8_t fillenable)
{
    // Bounding rectangle
	uint8_t maxx,maxy,minx,miny;
	uint8_t x1 = p[1];
	uint8_t y1 = p[0];
	uint8_t x2 = p[3];
	uint8_t y2 = p[2];
	uint8_t x3 = p[5];
	uint8_t y3 = p[4];
	uint8_t x4 = p[7];
	uint8_t y4 = p[6];
	
	maxx = x1>x2?(x1>x3?x1:x3):(x2>x3?x2:x3);
	maxx = maxx>x4?maxx:x4;
	minx = x1<x2?(x1<x3?x1:x3):(x2<x3?x2:x3);
	minx = minx<x4?minx:x4;
	maxy = y1>y2?(y1>y3?y1:y3):(y2>y3?y2:y3);
	maxy = maxy>y4?maxy:y4;
	miny = y1<y2?(y1<y3?y1:y3):(y2<y3?y2:y3);
	miny = miny<y4?miny:y4;

	if(fillenable)
	{
		// Scan through bounding rectangle
		for(int y = miny; y < maxy; y++)
		{
			for(int x = minx; x < maxx; x++)
			{
				// When all half-space functions positive, pixel is in triangle
				if(((x1 - x) * (y2 - y) - (y1 - y) * (x2 - x) >= 0) 
					&& ((x2 - x) * (y3 - y) - (y2 - y) * (x3 - x) >= 0) 
					&& ((x3 - x) * (y4 - y) - (y3 - y) * (x4 - x) >= 0)
					&& ((x4 - x) * (y1 - y) - (y4 - y) * (x1 - x) >= 0))
				{
					g_dispBuf[y][x] = pencolor;
				}
			}
		}
	}
	else
	{
		LCD_SetLine(y1, x1, y2, x2, pencolor, linethick);
		LCD_SetLine(y2, x2, y3, x3, pencolor, linethick);
		LCD_SetLine(y3, x3, y4, x4, pencolor, linethick);
		LCD_SetLine(y4, x4, y1, x1, pencolor, linethick);
	}
}

/**
  * @brief  Draw an circle (最大圆耗时 < 45ms)
  * @param  centerx: Center X coordinate.
  * @param  centery: Center Y coordinate.
  * @param  radius: Circle radius
  * @param  pencolor: pen color.
  * @param  thickness: Circle thickness.
  * @param  fillenable: Fill Enable.
  * @retval
  */
void LCD_SetCircle( uint16_t centery, uint16_t centerx, uint16_t radius,
					uint16_t pencolor, uint16_t thickness, uint8_t fillenable)
{
	uint16_t i,j;
	int32_t a,b,c;
	uint16_t radius_max,radius_min;
	uint16_t x_max,y_max;
	uint16_t x_min,y_min;
	
	//外圈半径
	radius_max = radius;
	
	//内圈半径
	if(thickness < radius)
	{
		radius_min = radius - thickness;
	}
	else
	{
		radius_min = 0;
	}
	
	//将图像整体向右移一个像素
//	centerx += 1;
	
	//防止超出边界
	y_max = centery + radius_max;
	if(y_max < LCD_LINE_CNT_MAX)
	{
		y_max += 1;
	}
	else
	{
		y_max = LCD_LINE_CNT_MAX;
	}
	
	if(centery < radius_max)
	{
		y_min = 0;
	}
	else
	{
		y_min = centery - radius_max;
	}
	
	x_max = centerx + radius_max;
	if(x_max < LCD_PIXEL_ONELINE_MAX)
	{
		x_max += 1;
	}
	else
	{
		x_max = LCD_PIXEL_ONELINE_MAX;
	}
	
	if(centerx < radius_max)
	{
		x_min = 0;
	}
	else
	{
		x_min = centerx - radius_max;
	}
	
	b = radius_max * radius_max;
	c = radius_min * radius_min;
	
	if(fillenable)
	{
		//填充颜色
		for(i = y_min; i < y_max; i++)
		{
			for(j = x_min; j < x_max; j++)
			{
				a = (i - centery)*(i - centery ) + (j - centerx)*(j - centerx);
				if(a <= b)
				{
					g_dispBuf[i][j] = pencolor;
				}
			}
		}
	}
	else
	{
		//圆环
		for(i = y_min; i < y_max; i++)
		{
			for(j = x_min; j < x_max; j++)
			{
				a = (i - centery)*(i - centery ) + (j - centerx)*(j - centerx);
				if((a <= b) && (a >= c))
				{
					g_dispBuf[i][j] = pencolor;
				}
			}
		}
	}	
/*	
	int16_t y = 0;
    int16_t err = 0;
    int16_t x = radius;
	
    while (x >= y)
    {
        if (fillenable)
        {
            if ((-y + centerx < 0) || (-x + centerx < 0))
            {
				LCD_SetRectangle((-x + centery), 1, 0, (y + centerx + 1), pencolor, 0, 0, LCD_FILL_ENABLE);
				LCD_SetRectangle((-y + centery), 1, 0, (x + centerx + 1), pencolor, 0, 0, LCD_FILL_ENABLE);
				LCD_SetRectangle((y + centery), 1, 0, (x + centerx + 1), pencolor, 0, 0, LCD_FILL_ENABLE);
				LCD_SetRectangle((x + centery), 1, 0, (y + centerx + 1), pencolor, 0, 0, LCD_FILL_ENABLE);
            }
            else
            {
				LCD_SetRectangle((-x + centery), 1, (-y + centerx), (2 * y + 1), pencolor, 0, 0, LCD_FILL_ENABLE);
				LCD_SetRectangle((-y + centery), 1, (-x + centerx), (2 * x + 1), pencolor, 0, 0, LCD_FILL_ENABLE);
				LCD_SetRectangle((y + centery), 1, (-x + centerx), (2 * x + 1), pencolor, 0, 0, LCD_FILL_ENABLE);
				LCD_SetRectangle((x + centery), 1, (-y + centerx), (2 * y + 1), pencolor, 0, 0, LCD_FILL_ENABLE);			
            }
        }
        else
        {
            g_dispBuf[(x + centery)][(y + centerx)] = pencolor;
            g_dispBuf[(x + centery)][(-y + centerx)] = pencolor;
            g_dispBuf[(y + centery)][(x + centerx)] = pencolor;
            g_dispBuf[(y + centery)][(-x + centerx)] = pencolor;
            g_dispBuf[(-x + centery)][(-y + centerx)] = pencolor;
            g_dispBuf[(-x + centery)][(y + centerx)] = pencolor;
            g_dispBuf[(-y + centery)][(-x + centerx)] = pencolor;
            g_dispBuf[(-y + centery)][(x + centerx)] = pencolor;
        }

        if (err <= 0)
        {
            y += 1;
            err += (2 * y + 1);
        }
        if (err > 0)
        {
            x -= 1;
            err -= (2 * x + 1);
		}
    }
*/
}
/*
uint32_t LCD_RGB16_to_RGB24(uint16_t data)
{
	uint32_t color;
	uint8_t R5,G6,B5;
	uint8_t R8,G8,B8;
	
	R5 = (data & 0xF800) >> 11;
	G6 = (data & 0x7E0) >> 5;
	B5 = (data & 0x1F);
	
	R8 = ( R5 * 527 + 23 ) >> 6;
	G8 = ( G6 * 259 + 33 ) >> 6;
	B8 = ( B5 * 527 + 23 ) >> 6;
	
	color = (R8 << 16) | (B8 << 8) | G8;
	
	return color;
} 

void LCD_SetTest(uint8_t t_x,uint8_t t_y,uint8_t size,uint8_t *p_font)
{
	uint16_t i,j,k;
	uint32_t color4bit,color;
	uint32_t gray;
	uint8_t x,y,temp;
	uint8_t width;
	
	switch(size)
	{
		case 16:
			width = 16;
			break;
		case 18:
			width = 24;
			break;
		case 20:
			width = 24;
			break;
		case 24:
			width = 24;
			break;
		case 32:
			width = 32;
			break;
		default:
			return;
	}
	
	x = t_x;
	y = t_y;
	
	for(i = 0; i < size; i++)
	{
		for(j = 0; j < width/2;j++)
		{
			temp = *p_font++;
			for(k = 0; k < 2;k++)
			{
				color4bit = (temp >> 4);
				color4bit= (15-color4bit)*255/15;
				gray =(color4bit*77+color4bit*150+color4bit*29+128)/256;
				gray=color4bit/8;
				color = (0x001f&gray)<<11;
				color = color|(((0x003f)&(gray*2))<<5);
				color = color|(0x001f&gray);
				
				//RGB565 --> RGB888
				gray = LCD_RGB16_to_RGB24(color) & 0xC0C0C0;
				color = ((gray & 0x800000) >> 17);
				color |= ((gray & 0x400000) >> 20);
				color |= ((gray & 0x8000) >> 10);
				color |= ((gray & 0x4000) >> 13);
				color |= ((gray & 0x80) >> 3);
				color |= ((gray & 0x40) >> 6);
				
				g_dispBuf[x][y++] = color;
//				DRV_LCD_LOG_PRINTF("0x%02x,",color);
				temp <<= 4;
			}
		}
//		DRV_LCD_LOG_PRINTF("\n");
		x++;
		y = t_y;
	}
//	DRV_LCD_LOG_PRINTF("\n");
}

const uint8_t t_16_1[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x81,0x00,0x00,0x3A,0x20,0x00,0x00,0x06,0xFD,0x20,0x00,0x6E,0xFC,0x40,0x00,0x00,0x6F,0xB0,0x00,0x00,0x6F,0x70,0x00,0x00,0x04,0x00,0x8F,0xFF,0xF1,0x00,0x00,0x07,0x10,0x00,0x24,0x4A,0xF0,0x08,0x30,0x3F,0xE4,0x01,0x44,0x48,0xF1,0x2F,0xE0,0x03,0xDD,0x14,0xFF,0xF8,0xF8,0xDC,0x10,0x00,0x11,0x00,0x06,0xF8,0xFF,0x90,0x00,0x00,0x17,0x00,0x0A,0xB8,0xFE,0x90,0x00,0x00,0x5F,0x40,0x2F,0x68,0xF5,0xF6,0x00,0x00,0xAE,0x00,0xBE,0x08,0xF0,0xAF,0x60,0x02,0xF8,0x1A,0xF4,0x08,0xF0,0x1D,0xF8,0x0A,0xF2,0x9F,0x61,0x4A,0xF0,0x01,0xC1,0x1E,0xD0,0x04,0x00,0xEF,0xD0,0x00,0x00,0x00,0x10,0x00,0x00,0x55,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xA3,0x00,0x00,0x08,0xF0,0x00,0x00,0x03,0xFF,0x60,0x00,0x08,0xF0,0x00,0x00,0x00,0x1D,0xB0,0x99,0x08,0xF0,0x00,0x00,0x00,0x01,0x00,0xCC,0x08,0xF1,0x6B,0x40,0x09,0x50,0x00,0xCC,0x2B,0xFF,0xFF,0x10,0x1C,0xF9,0x12,0xDF,0xFF,0xF3,0x4F,0x00,0x00,0xAB,0x9F,0xFE,0x38,0xF0,0x4F,0x00,0x00,0x00,0x23,0xCC,0x08,0xF0,0x4F,0x30,0x00,0x0B,0x30,0xCC,0x08,0xF4,0x8F,0x30,0x00,0x5F,0x30,0xCC,0x08,0xF7,0xFC,0x00,0x00,0xAE,0x00,0xCC,0x08,0xF1,0x21,0x00,0x02,0xF9,0x00,0xCC,0x04,0x80,0x04,0xE4,0x0B,0xF3,0x00,0xBF,0x88,0x88,0x8C,0xF4,0x17,0xC0,0x00,0x4F,0xFF,0xFF,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x60,0x01,0xD3,0x00,0x0E,0x70,0x00,0x0A,0xF9,0x00,0xDA,0x00,0x3F,0x20,0x00,0x00,0xAF,0x84,0x77,0x41,0xAF,0xFF,0xF4,0x00,0x02,0xFF,0xFF,0xF2,0xF6,0x44,0x41,0x06,0x00,0x0C,0x80,0x0C,0xE4,0x44,0x40,0x5F,0xC1,0x0C,0xC8,0xBE,0x8C,0xCF,0xF0,0x03,0xF7,0x0C,0xED,0xF0,0x00,0x6F,0x30,0x00,0x10,0x0D,0x64,0xF0,0x04,0xF5,0x00,0x00,0x53,0x0F,0x44,0xD6,0xCD,0xFC,0xC3,0x00,0xBC,0x2F,0x26,0xC4,0x8A,0xF8,0x82,0x01,0xF6,0x6E,0x08,0xC0,0x04,0xF0,0x00,0x06,0xF2,0xDA,0x08,0x90,0x04,0xF0,0x00,0x0E,0xD5,0xF4,0x8E,0x80,0x25,0xF0,0x00,0x4E,0x7B,0xA0,0xBE,0x30,0xCF,0xE0,0x00,0x00,0x10,0x10,0x00,0x00,0x47,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x81,0x00,0x00,0x3A,0x20,0x00,0x00,0x06,0xFD,0x20,0x00,0x6E,0xFC,0x40,0x00,0x00,0x6F,0xB0,0x00,0x00,0x6F,0x70,0x00,0x00,0x04,0x00,0x8F,0xFF,0xF1,0x00,0x00,0x07,0x10,0x00,0x24,0x4A,0xF0,0x08,0x30,0x3F,0xE4,0x01,0x44,0x48,0xF1,0x2F,0xE0,0x03,0xDD,0x14,0xFF,0xF8,0xF8,0xDC,0x10,0x00,0x11,0x00,0x06,0xF8,0xFF,0x90,0x00,0x00,0x17,0x00,0x0A,0xB8,0xFE,0x90,0x00,0x00,0x5F,0x40,0x2F,0x68,0xF5,0xF6,0x00,0x00,0xAE,0x00,0xBE,0x08,0xF0,0xAF,0x60,0x02,0xF8,0x1A,0xF4,0x08,0xF0,0x1D,0xF8,0x0A,0xF2,0x9F,0x61,0x4A,0xF0,0x01,0xC1,0x1E,0xD0,0x04,0x00,0xEF,0xD0,0x00,0x00,0x00,0x10,0x00,0x00,0x55,0x00,0x00,0x00};
const uint8_t t_24_1[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x2C,0x60,0x00,0x00,0x00,0x1F,0xD6,0x00,0x00,0x00,0x00,0x00,0xCF,0xF9,0x00,0x00,0x00,0x6F,0xFF,0xE6,0x00,0x00,0x00,0x00,0x1A,0xFF,0xD1,0x00,0x00,0x01,0x8F,0xFF,0xF3,0x00,0x00,0x00,0x00,0xAF,0xD3,0x00,0x00,0x00,0x01,0x8F,0x60,0x00,0x00,0x00,0x00,0x08,0x10,0x04,0xFF,0xFF,0xFF,0x81,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFD,0xCC,0xFF,0x80,0x00,0x30,0x00,0x03,0xB2,0x00,0x00,0x00,0x00,0x00,0xCF,0x80,0x00,0xE6,0x00,0x1E,0xFF,0x70,0x00,0x00,0x00,0x00,0xCF,0x80,0x08,0xFF,0x50,0x02,0xDF,0xFC,0x10,0x3C,0xCC,0xC8,0xCF,0xD0,0x3F,0xFB,0x10,0x00,0x1A,0xFA,0x10,0x4F,0xFF,0xF8,0xCF,0xF5,0xDF,0x80,0x00,0x00,0x00,0x40,0x00,0x14,0x4A,0xF7,0xCF,0xFF,0xE4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xF3,0xCF,0xFF,0x60,0x00,0x00,0x00,0x00,0x96,0x10,0x00,0x1F,0xF0,0xCF,0xCF,0xF1,0x00,0x00,0x00,0x00,0xEF,0x60,0x00,0x8F,0xA0,0xCF,0x8B,0xFC,0x00,0x00,0x00,0x03,0xFF,0x10,0x01,0xFF,0x30,0xCF,0x81,0xFF,0xA0,0x00,0x00,0x0A,0xFB,0x00,0x0C,0xFB,0x00,0xCF,0x80,0x4F,0xFB,0x10,0x00,0x1F,0xF6,0x01,0xAF,0xF2,0x00,0xCF,0x80,0x06,0xFF,0xE5,0x00,0x8F,0xF0,0x4D,0xFF,0x50,0x00,0xCF,0x80,0x00,0xAF,0xF1,0x01,0xFF,0xA0,0x6F,0xF6,0x03,0x54,0xEF,0x80,0x00,0x07,0x60,0x0C,0xFF,0x50,0x03,0x40,0x00,0xEF,0xFF,0x70,0x00,0x00,0x00,0x01,0x6D,0x00,0x00,0x00,0x00,0x9F,0xF8,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x22,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x9C,0x60,0x00,0x00,0x00,0x00,0x2D,0xC1,0x00,0x00,0x00,0x00,0xCF,0x60,0x00,0x00,0x00,0x00,0x6F,0xFF,0x30,0x00,0x00,0x00,0xCF,0x40,0x00,0x00,0x00,0x00,0x04,0xFF,0xF6,0x03,0x43,0x00,0xCF,0x40,0x00,0x00,0x00,0x00,0x00,0x3F,0xB1,0x0B,0xF8,0x00,0xCF,0x40,0x00,0x00,0x00,0x00,0x00,0x03,0x00,0x08,0xF8,0x00,0xCF,0x40,0x05,0xA3,0x00,0x00,0x10,0x00,0x00,0x08,0xF8,0x00,0xCF,0x9A,0xFF,0xF4,0x00,0x03,0xFA,0x10,0x00,0x08,0xF8,0x16,0xEF,0xFF,0xFF,0xF4,0x00,0x08,0xFF,0xE4,0x00,0x08,0xFF,0xFF,0xFF,0xB5,0x0F,0xF4,0x00,0x00,0x5F,0xFF,0x57,0xDF,0xFF,0xFA,0xEF,0x40,0x0F,0xF4,0x00,0x00,0x03,0xF6,0x1F,0xFF,0xFA,0x00,0xCF,0x40,0x0F,0xF4,0x00,0x00,0x00,0x10,0x08,0x58,0xF8,0x00,0xCF,0x40,0x0D,0xF4,0x00,0x00,0x00,0x20,0x00,0x08,0xF8,0x00,0xCF,0x40,0x0C,0xF4,0x00,0x00,0x00,0x9E,0x60,0x08,0xF8,0x00,0xCF,0x64,0x9F,0xF4,0x00,0x00,0x00,0xEF,0x70,0x08,0xF8,0x00,0xCF,0x4C,0xFF,0xD0,0x00,0x00,0x02,0xFF,0x20,0x08,0xF8,0x00,0xCF,0x65,0xC8,0x10,0x00,0x00,0x09,0xFC,0x00,0x08,0xF8,0x00,0xCF,0x80,0x00,0x20,0x00,0x00,0x1F,0xF6,0x00,0x08,0xF8,0x00,0x88,0x40,0x00,0x5E,0x71,0x00,0x8F,0xF1,0x00,0x08,0xF9,0x00,0x00,0x00,0x00,0x9F,0xF2,0x03,0xFF,0xB0,0x00,0x07,0xFF,0xCC,0xCC,0xCC,0xCC,0xFF,0xD0,0x05,0xCF,0x60,0x00,0x02,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x40,0x00,0x02,0x20,0x00,0x00,0x24,0x44,0x44,0x44,0x44,0x42,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x40,0x00,0x00,0x26,0x10,0x00,0x00,0x00,0x6D,0x10,0x00,0x2F,0xE0,0x00,0x00,0x7F,0xD0,0x00,0x00,0x02,0xFF,0xD3,0x00,0x0C,0xF5,0x00,0x00,0xDF,0x50,0x00,0x00,0x00,0x3F,0xFF,0x30,0x07,0xE7,0x00,0x02,0xFF,0x88,0x88,0x60,0x00,0x03,0xFE,0xC8,0x89,0x88,0x86,0x08,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x31,0xFF,0xFF,0xFF,0xFC,0x1F,0xF4,0x44,0x44,0x60,0x00,0x00,0x00,0x88,0xFE,0x88,0x86,0xBF,0x80,0x00,0x00,0x00,0x06,0xA0,0x00,0x00,0xFC,0x00,0x06,0xFF,0x74,0x44,0x44,0x20,0x3F,0xFD,0x20,0x00,0xFD,0x44,0x7F,0xFE,0xFF,0xFF,0xFF,0x80,0x03,0xFF,0xF5,0x02,0xFF,0xFF,0xF9,0x72,0x40,0x08,0xFD,0x30,0x00,0x3D,0xD1,0x04,0xFE,0x8A,0xF8,0x00,0x00,0x6F,0xD1,0x00,0x00,0x02,0x00,0x04,0xF8,0x06,0xF8,0x00,0x05,0xFF,0x30,0x00,0x00,0x00,0x00,0x05,0xF8,0x08,0xF4,0x31,0x08,0xF9,0x02,0x40,0x00,0x03,0xB3,0x08,0xF7,0x08,0xF4,0xCF,0xFF,0xFF,0xFF,0xF0,0x00,0x07,0xFB,0x0B,0xF4,0x08,0xF4,0x9C,0xCE,0xFE,0xCC,0xC0,0x00,0x0D,0xF6,0x0E,0xF0,0x0A,0xF1,0x00,0x08,0xF8,0x00,0x00,0x00,0x2F,0xF1,0x3F,0xD0,0x0C,0xF0,0x00,0x08,0xF8,0x00,0x00,0x00,0x8F,0xB0,0x9F,0x70,0x0C,0xF0,0x00,0x08,0xF8,0x00,0x00,0x00,0xEF,0x61,0xFF,0x20,0x0F,0xC0,0x00,0x08,0xF8,0x00,0x00,0x07,0xFF,0x19,0xFA,0x2B,0xDF,0xC0,0x24,0x0A,0xF8,0x00,0x00,0x1F,0xFD,0x4F,0xF2,0x09,0xFF,0x50,0x0A,0xFF,0xF7,0x00,0x00,0x01,0x66,0x06,0x80,0x05,0x83,0x00,0x05,0xFF,0xC1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x42,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x2C,0x60,0x00,0x00,0x00,0x1F,0xD6,0x00,0x00,0x00,0x00,0x00,0xCF,0xF9,0x00,0x00,0x00,0x6F,0xFF,0xE6,0x00,0x00,0x00,0x00,0x1A,0xFF,0xD1,0x00,0x00,0x01,0x8F,0xFF,0xF3,0x00,0x00,0x00,0x00,0xAF,0xD3,0x00,0x00,0x00,0x01,0x8F,0x60,0x00,0x00,0x00,0x00,0x08,0x10,0x04,0xFF,0xFF,0xFF,0x81,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFD,0xCC,0xFF,0x80,0x00,0x30,0x00,0x03,0xB2,0x00,0x00,0x00,0x00,0x00,0xCF,0x80,0x00,0xE6,0x00,0x1E,0xFF,0x70,0x00,0x00,0x00,0x00,0xCF,0x80,0x08,0xFF,0x50,0x02,0xDF,0xFC,0x10,0x3C,0xCC,0xC8,0xCF,0xD0,0x3F,0xFB,0x10,0x00,0x1A,0xFA,0x10,0x4F,0xFF,0xF8,0xCF,0xF5,0xDF,0x80,0x00,0x00,0x00,0x40,0x00,0x14,0x4A,0xF7,0xCF,0xFF,0xE4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xF3,0xCF,0xFF,0x60,0x00,0x00,0x00,0x00,0x96,0x10,0x00,0x1F,0xF0,0xCF,0xCF,0xF1,0x00,0x00,0x00,0x00,0xEF,0x60,0x00,0x8F,0xA0,0xCF,0x8B,0xFC,0x00,0x00,0x00,0x03,0xFF,0x10,0x01,0xFF,0x30,0xCF,0x81,0xFF,0xA0,0x00,0x00,0x0A,0xFB,0x00,0x0C,0xFB,0x00,0xCF,0x80,0x4F,0xFB,0x10,0x00,0x1F,0xF6,0x01,0xAF,0xF2,0x00,0xCF,0x80,0x06,0xFF,0xE5,0x00,0x8F,0xF0,0x4D,0xFF,0x50,0x00,0xCF,0x80,0x00,0xAF,0xF1,0x01,0xFF,0xA0,0x6F,0xF6,0x03,0x54,0xEF,0x80,0x00,0x07,0x60,0x0C,0xFF,0x50,0x03,0x40,0x00,0xEF,0xFF,0x70,0x00,0x00,0x00,0x01,0x6D,0x00,0x00,0x00,0x00,0x9F,0xF8,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x22,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_32_1[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x01,0x81,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFD,0x20,0x00,0x00,0x00,0x00,0x1D,0xFF,0x92,0x00,0x00,0x00,0x00,0x00,0x00,0x2F,0xFF,0xF5,0x00,0x00,0x00,0x00,0x7F,0xFF,0xFF,0xA2,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFF,0x80,0x00,0x00,0x00,0x02,0x8F,0xFF,0xFF,0xA4,0x00,0x00,0x00,0x00,0x00,0x3F,0xFF,0xFA,0x00,0x00,0x00,0x00,0x01,0x8F,0xFF,0xF7,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0xE3,0x00,0x03,0x00,0x00,0x00,0x02,0xAF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x10,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x31,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x08,0x88,0x88,0x8F,0xFF,0x00,0x00,0x0A,0x10,0x00,0x00,0x9E,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x00,0x00,0x4F,0xA0,0x00,0x0A,0xFF,0xF9,0x10,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x00,0x00,0xDF,0xFA,0x00,0x02,0xDF,0xFF,0xD3,0x00,0x02,0x44,0x44,0x44,0x1F,0xFF,0x30,0x08,0xFF,0xFA,0x10,0x00,0x0A,0xFF,0xFF,0x30,0x08,0xFF,0xFF,0xFF,0x3F,0xFF,0xA0,0x3F,0xFF,0x60,0x00,0x00,0x00,0x6F,0xF5,0x00,0x08,0xFF,0xFF,0xFF,0x0F,0xFF,0xF5,0xFF,0xE3,0x00,0x00,0x00,0x00,0x06,0x30,0x00,0x02,0x44,0x4D,0xFF,0x0F,0xFF,0xFF,0xFB,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xFC,0x0F,0xFF,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x2F,0xF8,0x0F,0xFF,0xFF,0xD0,0x00,0x00,0x00,0x00,0x00,0x03,0xE6,0x20,0x00,0x00,0x7F,0xF3,0x0F,0xFF,0x9F,0xF7,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xA0,0x00,0x00,0xEF,0xE0,0x0F,0xFF,0x1F,0xFF,0x30,0x00,0x00,0x00,0x00,0x0D,0xFF,0x30,0x00,0x06,0xFF,0x80,0x0F,0xFF,0x05,0xFF,0xF2,0x00,0x00,0x00,0x00,0x2F,0xFE,0x00,0x00,0x1F,0xFF,0x10,0x0F,0xFF,0x00,0xAF,0xFD,0x20,0x00,0x00,0x00,0x8F,0xF9,0x00,0x01,0xDF,0xF8,0x00,0x0F,0xFF,0x00,0x1D,0xFF,0xF4,0x00,0x00,0x00,0xEF,0xF3,0x00,0x1D,0xFF,0xD0,0x00,0x0F,0xFF,0x00,0x03,0xFF,0xFF,0xA2,0x00,0x06,0xFF,0xD0,0x03,0xDF,0xFF,0x30,0x00,0x0F,0xFF,0x00,0x00,0x3F,0xFF,0xF4,0x00,0x0E,0xFF,0x70,0x6F,0xFF,0xF5,0x00,0x00,0x0F,0xFF,0x00,0x00,0x03,0xFF,0x50,0x00,0x8F,0xFF,0x20,0x1B,0xFF,0x60,0x03,0x88,0x8F,0xFF,0x00,0x00,0x00,0x3C,0x00,0x03,0xFF,0xFD,0x00,0x00,0x93,0x00,0x01,0xFF,0xFF,0xFF,0x00,0x00,0x00,0x00,0x00,0x03,0x9E,0xF6,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x61,0x00,0x00,0x00,0x00,0x00,0x4F,0xC8,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x44,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x36,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0xA1,0x00,0x00,0x00,0x00,0x00,0x0F,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x0A,0xFF,0xFD,0x20,0x00,0x00,0x00,0x00,0x0F,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xF3,0x00,0x00,0x00,0x00,0x0F,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0xFE,0x10,0x6C,0xC6,0x00,0x0F,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xC1,0x00,0x8F,0xF6,0x00,0x0F,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x05,0x00,0x00,0x8F,0xF4,0x00,0x0F,0xFC,0x00,0x00,0x39,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xF4,0x00,0x0F,0xFC,0x05,0xAE,0xFF,0x40,0x00,0x00,0x06,0x10,0x00,0x00,0x00,0x8F,0xF4,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x40,0x00,0x00,0xAF,0xE4,0x00,0x00,0x00,0x8F,0xF4,0x16,0xBF,0xFF,0xFF,0xFE,0xFF,0x40,0x00,0x03,0xFF,0xFF,0x91,0x00,0x00,0x8F,0xFD,0xFF,0xFF,0xFF,0xA5,0x08,0xFF,0x40,0x00,0x00,0x3D,0xFF,0xFD,0x30,0x27,0xEF,0xFF,0xFF,0xFF,0xFC,0x00,0x08,0xFF,0x40,0x00,0x00,0x01,0xBF,0xFF,0x5D,0xFF,0xFF,0xFF,0xA5,0x0F,0xFC,0x00,0x08,0xFF,0x40,0x00,0x00,0x00,0x0A,0xD2,0x0C,0xFF,0xFF,0xF4,0x00,0x0F,0xFC,0x00,0x08,0xFF,0x40,0x00,0x00,0x00,0x00,0x10,0x07,0xA5,0x8F,0xF4,0x00,0x0F,0xFC,0x00,0x08,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xF4,0x00,0x0F,0xFC,0x00,0x08,0xFF,0x40,0x00,0x00,0x00,0x00,0x81,0x00,0x00,0x8F,0xF4,0x00,0x0F,0xFC,0x00,0x08,0xFF,0x40,0x00,0x00,0x00,0x02,0xFF,0xB0,0x00,0x8F,0xF4,0x00,0x0F,0xFC,0x58,0x9F,0xFF,0x40,0x00,0x00,0x00,0x06,0xFF,0xA0,0x00,0x8F,0xF4,0x00,0x0F,0xFC,0x2F,0xFF,0xFF,0x10,0x00,0x00,0x00,0x0B,0xFF,0x50,0x00,0x8F,0xF4,0x00,0x0F,0xFC,0x0A,0xFF,0xC3,0x00,0x00,0x00,0x00,0x1F,0xFF,0x00,0x00,0x8F,0xF4,0x00,0x0F,0xFE,0x04,0x63,0x00,0x00,0x00,0x00,0x00,0x7F,0xFA,0x00,0x00,0x8F,0xF4,0x00,0x1F,0xFF,0x00,0x00,0x03,0x10,0x00,0x00,0x00,0xEF,0xF5,0x00,0x00,0x8F,0xF4,0x00,0x3C,0xCC,0x00,0x00,0x08,0xE7,0x20,0x00,0x06,0xFF,0xF0,0x00,0x00,0x8F,0xF5,0x00,0x00,0x00,0x00,0x00,0x09,0xFF,0xF0,0x00,0x1E,0xFF,0x90,0x00,0x00,0x8F,0xFB,0x10,0x00,0x00,0x00,0x00,0x1E,0xFF,0xB0,0x00,0xAF,0xFF,0x30,0x00,0x00,0x4F,0xFF,0xFE,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x60,0x01,0xAF,0xFE,0x00,0x00,0x00,0x0E,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFD,0x00,0x00,0x01,0x88,0x00,0x00,0x00,0x03,0xBC,0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0xA1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x30,0x00,0x00,0x02,0x8C,0x30,0x00,0x00,0x00,0xCC,0x72,0x00,0x00,0x00,0x00,0x1B,0xF6,0x00,0x00,0x02,0xFF,0xA0,0x00,0x00,0x00,0xFF,0xE1,0x00,0x00,0x00,0x00,0x8F,0xFF,0x80,0x00,0x00,0xBF,0xF1,0x00,0x00,0x05,0xFF,0x80,0x00,0x00,0x00,0x00,0x0A,0xFF,0xFA,0x00,0x00,0x6F,0xF6,0x00,0x00,0x0A,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0xAF,0xFF,0xA0,0x00,0x2B,0x72,0x00,0x00,0x1F,0xFF,0xCC,0xCC,0xCF,0x80,0x00,0x00,0x0A,0xFD,0xB8,0x88,0x88,0x88,0x8C,0x30,0x8F,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x00,0x71,0xCF,0xFF,0xFF,0xFF,0xFF,0x41,0xFF,0xD8,0x88,0x88,0x88,0x40,0x00,0x00,0x00,0x00,0xCE,0xEF,0xFC,0xCC,0xFF,0x48,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x8F,0xF0,0x00,0x00,0x3F,0xFB,0x00,0x00,0x00,0x00,0x00,0x02,0xDB,0x10,0x00,0x00,0x8F,0xF0,0x00,0x01,0xEF,0xFA,0x88,0x88,0x88,0x88,0x20,0x1E,0xFF,0xE3,0x00,0x00,0x8F,0xF0,0x00,0x1C,0xFF,0xDF,0xFF,0xFF,0xFF,0xFF,0x40,0x03,0xFF,0xFF,0x60,0x00,0x8F,0xFC,0xCC,0xCC,0x9E,0x48,0x88,0x88,0xFF,0xFE,0x30,0x00,0x1D,0xFF,0xF5,0x00,0x8F,0xFF,0xFF,0xFF,0x01,0x00,0x00,0x07,0xFF,0xA1,0x00,0x00,0x01,0xDF,0x50,0x00,0x8F,0xE8,0x8C,0xFF,0x00,0x00,0x00,0x6F,0xFC,0x00,0x00,0x00,0x00,0x13,0x00,0x00,0xBF,0xC0,0x08,0xFF,0x00,0x00,0x05,0xFF,0xE1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xCF,0xC0,0x08,0xFC,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0xDF,0xA0,0x09,0xFC,0x3A,0x88,0x8D,0xFF,0x88,0x89,0x90,0x00,0x00,0x0F,0xA3,0x00,0xFF,0x80,0x0C,0xFC,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x4F,0xFA,0x03,0xFF,0x50,0x0C,0xF8,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x9F,0xF5,0x07,0xFF,0x30,0x0C,0xF8,0x00,0x00,0x08,0xFF,0x00,0x00,0x00,0x00,0x00,0xEF,0xF0,0x0B,0xFF,0x00,0x0E,0xF8,0x00,0x00,0x08,0xFF,0x00,0x00,0x00,0x00,0x03,0xFF,0xA0,0x0F,0xFB,0x00,0x0F,0xF5,0x00,0x00,0x08,0xFF,0x00,0x00,0x00,0x00,0x09,0xFF,0x50,0x6F,0xF6,0x00,0x0F,0xF4,0x00,0x00,0x08,0xFF,0x00,0x00,0x00,0x00,0x1F,0xFF,0x10,0xCF,0xF1,0x00,0x4F,0xF3,0x00,0x00,0x08,0xFF,0x00,0x00,0x00,0x00,0x8F,0xFB,0x05,0xFF,0xA1,0x00,0x7F,0xF0,0x00,0x00,0x08,0xFF,0x00,0x00,0x00,0x01,0xFF,0xF6,0x1E,0xFF,0x21,0xFF,0xFF,0xF0,0x01,0x53,0x3D,0xFF,0x00,0x00,0x00,0x0B,0xFF,0xF1,0xBF,0xFA,0x00,0x8F,0xFF,0xA0,0x00,0xAF,0xFF,0xFF,0x00,0x00,0x00,0x03,0x9F,0xD0,0x3D,0xF1,0x00,0x4F,0xE8,0x10,0x00,0x2F,0xFF,0xF8,0x00,0x00,0x00,0x00,0x01,0x30,0x01,0x40,0x00,0x11,0x00,0x00,0x00,0x0E,0xFD,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x01,0x81,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFD,0x20,0x00,0x00,0x00,0x00,0x1D,0xFF,0x92,0x00,0x00,0x00,0x00,0x00,0x00,0x2F,0xFF,0xF5,0x00,0x00,0x00,0x00,0x7F,0xFF,0xFF,0xA2,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFF,0x80,0x00,0x00,0x00,0x02,0x8F,0xFF,0xFF,0xA4,0x00,0x00,0x00,0x00,0x00,0x3F,0xFF,0xFA,0x00,0x00,0x00,0x00,0x01,0x8F,0xFF,0xF7,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0xE3,0x00,0x03,0x00,0x00,0x00,0x02,0xAF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x10,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x31,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x08,0x88,0x88,0x8F,0xFF,0x00,0x00,0x0A,0x10,0x00,0x00,0x9E,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x00,0x00,0x4F,0xA0,0x00,0x0A,0xFF,0xF9,0x10,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x00,0x00,0xDF,0xFA,0x00,0x02,0xDF,0xFF,0xD3,0x00,0x02,0x44,0x44,0x44,0x1F,0xFF,0x30,0x08,0xFF,0xFA,0x10,0x00,0x0A,0xFF,0xFF,0x30,0x08,0xFF,0xFF,0xFF,0x3F,0xFF,0xA0,0x3F,0xFF,0x60,0x00,0x00,0x00,0x6F,0xF5,0x00,0x08,0xFF,0xFF,0xFF,0x0F,0xFF,0xF5,0xFF,0xE3,0x00,0x00,0x00,0x00,0x06,0x30,0x00,0x02,0x44,0x4D,0xFF,0x0F,0xFF,0xFF,0xFB,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xFC,0x0F,0xFF,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x2F,0xF8,0x0F,0xFF,0xFF,0xD0,0x00,0x00,0x00,0x00,0x00,0x03,0xE6,0x20,0x00,0x00,0x7F,0xF3,0x0F,0xFF,0x9F,0xF7,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xA0,0x00,0x00,0xEF,0xE0,0x0F,0xFF,0x1F,0xFF,0x30,0x00,0x00,0x00,0x00,0x0D,0xFF,0x30,0x00,0x06,0xFF,0x80,0x0F,0xFF,0x05,0xFF,0xF2,0x00,0x00,0x00,0x00,0x2F,0xFE,0x00,0x00,0x1F,0xFF,0x10,0x0F,0xFF,0x00,0xAF,0xFD,0x20,0x00,0x00,0x00,0x8F,0xF9,0x00,0x01,0xDF,0xF8,0x00,0x0F,0xFF,0x00,0x1D,0xFF,0xF4,0x00,0x00,0x00,0xEF,0xF3,0x00,0x1D,0xFF,0xD0,0x00,0x0F,0xFF,0x00,0x03,0xFF,0xFF,0xA2,0x00,0x06,0xFF,0xD0,0x03,0xDF,0xFF,0x30,0x00,0x0F,0xFF,0x00,0x00,0x3F,0xFF,0xF4,0x00,0x0E,0xFF,0x70,0x6F,0xFF,0xF5,0x00,0x00,0x0F,0xFF,0x00,0x00,0x03,0xFF,0x50,0x00,0x8F,0xFF,0x20,0x1B,0xFF,0x60,0x03,0x88,0x8F,0xFF,0x00,0x00,0x00,0x3C,0x00,0x03,0xFF,0xFD,0x00,0x00,0x93,0x00,0x01,0xFF,0xFF,0xFF,0x00,0x00,0x00,0x00,0x00,0x03,0x9E,0xF6,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x61,0x00,0x00,0x00,0x00,0x00,0x4F,0xC8,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};

const uint8_t t_16_1_5[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x91,0x00,0x00,0x3B,0x40,0x00,0x00,0x06,0xFE,0x30,0x00,0x8F,0xFC,0x40,0x00,0x00,0x6F,0xC0,0x20,0x01,0x8F,0x70,0x00,0x00,0x04,0x00,0x8F,0xFF,0xF3,0x00,0x00,0x08,0x20,0x00,0x24,0x4A,0xF0,0x09,0x30,0x4F,0xF5,0x01,0x44,0x49,0xF1,0x2F,0xE1,0x03,0xFD,0x24,0xFF,0xFA,0xF9,0xDD,0x30,0x00,0x31,0x01,0x4A,0xF8,0xFF,0xA1,0x00,0x00,0x27,0x00,0x0B,0xC8,0xFF,0xB0,0x00,0x00,0x6F,0x50,0x2F,0x68,0xF7,0xF6,0x00,0x00,0xCF,0x00,0xDF,0x18,0xF0,0xBF,0x70,0x02,0xF9,0x1C,0xF5,0x08,0xF0,0x1D,0xF9,0x0B,0xF3,0xAF,0x62,0x4A,0xF0,0x01,0xC1,0x2E,0xE0,0x04,0x00,0xEF,0xF0,0x00,0x10,0x00,0x30,0x00,0x00,0x57,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x40,0x00,0x00,0x01,0xC3,0x00,0x00,0x08,0xF0,0x00,0x00,0x03,0xFF,0x60,0x00,0x08,0xF0,0x00,0x00,0x00,0x3F,0xB1,0xCC,0x08,0xF0,0x00,0x00,0x00,0x02,0x00,0xCC,0x08,0xF2,0x7D,0x40,0x09,0x70,0x00,0xCC,0x3B,0xFF,0xFF,0x40,0x1D,0xFB,0x13,0xEF,0xFF,0xF5,0x4F,0x40,0x01,0xAB,0x9F,0xFE,0x58,0xF0,0x4F,0x40,0x00,0x01,0x25,0xCC,0x08,0xF0,0x4F,0x40,0x00,0x1B,0x30,0xCC,0x08,0xF4,0x9F,0x40,0x00,0x6F,0x50,0xCC,0x08,0xF8,0xFD,0x00,0x00,0xBF,0x00,0xCC,0x09,0xF1,0x31,0x00,0x02,0xFA,0x00,0xCC,0x06,0x80,0x05,0xE5,0x0C,0xF5,0x00,0xCF,0x88,0x88,0x8C,0xF6,0x17,0xD0,0x00,0x5F,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x70,0x02,0xD4,0x00,0x0F,0x70,0x00,0x0A,0xFA,0x00,0xEA,0x00,0x5F,0x30,0x00,0x00,0xAF,0x94,0x87,0x60,0xBF,0xFF,0xF4,0x00,0x03,0xFF,0xFF,0xF3,0xF6,0x44,0x41,0x18,0x10,0x0C,0x80,0x1D,0xE4,0x44,0x41,0x6F,0xD3,0x0C,0xC8,0xDF,0xCC,0xCF,0xF4,0x06,0xF7,0x0C,0xED,0xF1,0x00,0xAF,0x30,0x00,0x20,0x0F,0x84,0xF0,0x06,0xF6,0x00,0x00,0x53,0x0F,0x46,0xF7,0xCE,0xFC,0xD4,0x00,0xDD,0x4F,0x38,0xC4,0x8A,0xF8,0x82,0x01,0xF7,0x8F,0x08,0xC0,0x04,0xF0,0x00,0x07,0xF2,0xEA,0x09,0xC0,0x04,0xF0,0x00,0x1E,0xE7,0xF5,0x8F,0x81,0x37,0xF0,0x00,0x4E,0x9B,0xC0,0xBF,0x30,0xCF,0xF0,0x00,0x00,0x10,0x20,0x10,0x00,0x48,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x91,0x00,0x00,0x3B,0x40,0x00,0x00,0x06,0xFE,0x30,0x00,0x8F,0xFC,0x40,0x00,0x00,0x6F,0xC0,0x20,0x01,0x8F,0x70,0x00,0x00,0x04,0x00,0x8F,0xFF,0xF3,0x00,0x00,0x08,0x20,0x00,0x24,0x4A,0xF0,0x09,0x30,0x4F,0xF5,0x01,0x44,0x49,0xF1,0x2F,0xE1,0x03,0xFD,0x24,0xFF,0xFA,0xF9,0xDD,0x30,0x00,0x31,0x01,0x4A,0xF8,0xFF,0xA1,0x00,0x00,0x27,0x00,0x0B,0xC8,0xFF,0xB0,0x00,0x00,0x6F,0x50,0x2F,0x68,0xF7,0xF6,0x00,0x00,0xCF,0x00,0xDF,0x18,0xF0,0xBF,0x70,0x02,0xF9,0x1C,0xF5,0x08,0xF0,0x1D,0xF9,0x0B,0xF3,0xAF,0x62,0x4A,0xF0,0x01,0xC1,0x2E,0xE0,0x04,0x00,0xEF,0xF0,0x00,0x10,0x00,0x30,0x00,0x00,0x57,0x10,0x00,0x00,
							0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x48,0x88,0x88,0x84,0x00,0x00,0x00,0x00,0x8F,0xFF,0xFF,0xF8,0x00,0x00,0x00,0x00,0x24,0x44,0x4F,0xF3,0x00,0x00,0x00,0x00,0x00,0x00,0x9F,0x60,0x00,0x00,0x00,0x00,0x00,0x04,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x2F,0xB0,0x00,0x00,0x00,0x00,0x00,0x00,0x7F,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0xCF,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x58,0x82,0x00,0x00,0x00,0x00,0x00,0x0A,0xFE,0xFF,0x50,0x00,0x00,0x00,0x00,0x4F,0xA0,0x1E,0xE0,0x00,0x00,0x00,0x00,0x49,0x30,0x0C,0xF0,0x00,0x00,0x00,0x00,0x00,0x02,0x7F,0xC0,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x14,0x4D,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x05,0xF8,0x00,0x00,0x00,0x00,0x9F,0x30,0x05,0xF8,0x00,0x00,0x00,0x00,0x4F,0xD3,0x5D,0xF2,0x00,0x00,0x00,0x00,0x09,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x24,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x28,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x7A,0xC8,0x10,0x00,0x00,0x00,0x00,0x4F,0xFC,0xAF,0xD0,0x00,0x00,0x00,0x00,0x4F,0x90,0x07,0xF6,0x00,0x00,0x00,0x00,0x4F,0x40,0x01,0xF8,0x00,0x00,0x00,0x00,0x4F,0x40,0x00,0xF8,0x00,0x00,0x00,0x00,0x4F,0x50,0x05,0xF8,0x00,0x00,0x00,0x00,0x4F,0xD2,0x2D,0xF2,0x00,0x00,0x00,0x00,0x4F,0xEF,0xFF,0x60,0x00,0x00,0x00,0x00,0x14,0x13,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x6A,0xC8,0x10,0x00,0x00,0x00,0x00,0x4F,0xFD,0xCF,0xD0,0x00,0x00,0x00,0x00,0x4F,0xB0,0x08,0xF6,0x00,0x00,0x00,0x00,0x4F,0x40,0x04,0xF8,0x00,0x00,0x00,0x00,0x4F,0x40,0x04,0xF8,0x00,0x00,0x00,0x00,0x4F,0x60,0x06,0xF7,0x00,0x00,0x00,0x00,0x4F,0xD2,0x2D,0xF2,0x00,0x00,0x00,0x00,0x4F,0xEF,0xFF,0x50,0x00,0x00,0x00,0x00,0x4F,0x43,0x40,0x00,0x00,0x00,0x00,0x00,0x4F,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x6B,0xCA,0x28,0xCB,0x30,0x00,0x00,0x4F,0xFA,0xDF,0xFD,0xAF,0xF0,0x00,0x00,0x4F,0xB0,0x0E,0xF2,0x09,0xF4,0x00,0x00,0x4F,0x70,0x0C,0xF0,0x08,0xF4,0x00,0x00,0x4F,0x40,0x0C,0xF0,0x08,0xF4,0x00,0x00,0x4F,0x40,0x0C,0xF0,0x08,0xF4,0x00,0x00,0x4F,0x40,0x0C,0xF0,0x08,0xF4,0x00,0x00,0x4F,0x40,0x0C,0xF0,0x08,0xF4,0x00,0x00,0x14,0x10,0x03,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_24_1_5[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0x80,0x00,0x00,0x00,0x2F,0xE8,0x10,0x00,0x00,0x00,0x01,0xDF,0xFB,0x10,0x00,0x00,0x9F,0xFF,0xF8,0x10,0x00,0x00,0x00,0x1D,0xFF,0xD3,0x00,0x00,0x02,0xAF,0xFF,0xF3,0x00,0x00,0x00,0x01,0xDF,0xD3,0x01,0x44,0x00,0x02,0xAF,0x60,0x00,0x00,0x00,0x00,0x19,0x10,0x04,0xFF,0xFF,0xFF,0xC2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFF,0xFF,0xC0,0x00,0x40,0x00,0x03,0xD4,0x00,0x00,0x00,0x00,0x00,0xCF,0xC0,0x01,0xF7,0x00,0x1F,0xFF,0x90,0x00,0x00,0x00,0x00,0xCF,0xC0,0x08,0xFF,0x60,0x03,0xFF,0xFD,0x30,0x3C,0xCC,0xC9,0xCF,0xE0,0x3F,0xFD,0x30,0x00,0x1D,0xFA,0x10,0x4F,0xFF,0xFB,0xCF,0xF7,0xFF,0xA1,0x00,0x00,0x01,0x50,0x00,0x14,0x4C,0xF8,0xCF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0D,0xF5,0xCF,0xFF,0x90,0x00,0x00,0x00,0x00,0xA6,0x10,0x00,0x2F,0xF1,0xCF,0xFF,0xF3,0x00,0x00,0x00,0x01,0xFF,0x90,0x00,0x9F,0xB0,0xCF,0xCC,0xFD,0x10,0x00,0x00,0x06,0xFF,0x20,0x03,0xFF,0x50,0xCF,0xC2,0xFF,0xD1,0x00,0x00,0x0B,0xFD,0x00,0x1D,0xFC,0x00,0xCF,0xC0,0x6F,0xFD,0x20,0x00,0x2F,0xF7,0x01,0xDF,0xF3,0x00,0xCF,0xC0,0x0A,0xFF,0xF7,0x00,0xAF,0xF2,0x6F,0xFF,0x60,0x00,0xCF,0xC0,0x00,0xAF,0xF3,0x03,0xFF,0xD0,0x4F,0xF6,0x03,0x88,0xEF,0xC0,0x00,0x0A,0x80,0x1C,0xFF,0x70,0x03,0x60,0x00,0xEF,0xFF,0xA0,0x00,0x00,0x10,0x01,0x6E,0x10,0x00,0x00,0x00,0x9F,0xFB,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x34,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x10,0x00,0x00,0x00,0x00,0xCC,0x60,0x00,0x00,0x00,0x00,0x3D,0xD3,0x00,0x00,0x00,0x00,0xCF,0x80,0x00,0x00,0x00,0x00,0x9F,0xFF,0x60,0x00,0x00,0x00,0xCF,0x80,0x00,0x00,0x00,0x00,0x06,0xFF,0xF6,0x03,0x43,0x00,0xCF,0x80,0x00,0x00,0x00,0x00,0x00,0x6F,0xB1,0x0C,0xFB,0x00,0xCF,0x80,0x00,0x00,0x00,0x00,0x00,0x04,0x00,0x0C,0xF8,0x00,0xCF,0x80,0x26,0xB4,0x00,0x00,0x20,0x00,0x00,0x0C,0xF8,0x00,0xCF,0xCD,0xFF,0xF4,0x00,0x03,0xFC,0x20,0x00,0x0C,0xF8,0x38,0xFF,0xFF,0xFF,0xF4,0x00,0x0B,0xFF,0xF6,0x00,0x0C,0xFF,0xFF,0xFF,0xD6,0x1F,0xF4,0x00,0x00,0x7F,0xFF,0x9A,0xFF,0xFF,0xFB,0xEF,0x80,0x0F,0xF4,0x00,0x00,0x05,0xF6,0x2F,0xFF,0xFA,0x10,0xCF,0x80,0x0F,0xF4,0x00,0x00,0x00,0x10,0x09,0x6D,0xF8,0x00,0xCF,0x80,0x0F,0xF4,0x00,0x00,0x00,0x30,0x00,0x0C,0xF8,0x00,0xCF,0x80,0x0F,0xF4,0x00,0x00,0x00,0xBE,0x70,0x0C,0xF8,0x00,0xCF,0xB8,0xAF,0xF4,0x00,0x00,0x00,0xFF,0x90,0x0C,0xF8,0x00,0xCF,0x8C,0xFF,0xF1,0x00,0x00,0x05,0xFF,0x30,0x0C,0xF8,0x00,0xDF,0x86,0xEA,0x20,0x00,0x00,0x0A,0xFE,0x00,0x0C,0xF8,0x00,0xFF,0x80,0x00,0x31,0x00,0x00,0x2F,0xF9,0x00,0x0C,0xF8,0x00,0xCC,0x90,0x00,0x8E,0x82,0x00,0xAF,0xF3,0x00,0x0C,0xFC,0x00,0x00,0x00,0x00,0xAF,0xF4,0x04,0xFF,0xE0,0x00,0x09,0xFF,0xDC,0xCC,0xCC,0xCC,0xFF,0xF0,0x06,0xCF,0x90,0x00,0x04,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x60,0x00,0x03,0x20,0x00,0x00,0x48,0x88,0x88,0x88,0x88,0x84,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x02,0x40,0x00,0x00,0x46,0x10,0x00,0x00,0x00,0x7D,0x30,0x00,0x4F,0xF1,0x00,0x00,0x9F,0xE1,0x00,0x00,0x03,0xFF,0xF3,0x00,0x0E,0xF6,0x00,0x00,0xEF,0x60,0x00,0x00,0x00,0x3F,0xFF,0x60,0x09,0xF8,0x00,0x04,0xFF,0x98,0x88,0x60,0x00,0x03,0xFE,0xC8,0x89,0x88,0x88,0x0A,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x61,0xFF,0xFF,0xFF,0xFC,0x2F,0xF8,0x88,0x88,0x60,0x00,0x00,0x00,0x8A,0xFE,0x88,0x86,0xCF,0x80,0x00,0x00,0x00,0x06,0xB1,0x00,0x04,0xFC,0x00,0x08,0xFF,0x98,0x88,0x88,0x60,0x3F,0xFE,0x30,0x04,0xFD,0x44,0x7F,0xFF,0xFF,0xFF,0xFF,0xC0,0x06,0xFF,0xF6,0x04,0xFF,0xFF,0xFC,0x82,0x44,0x4D,0xFF,0x50,0x00,0x3F,0xD1,0x04,0xFF,0xCE,0xF8,0x00,0x00,0x9F,0xF3,0x00,0x00,0x03,0x00,0x04,0xFC,0x08,0xF8,0x00,0x07,0xFF,0x40,0x00,0x00,0x00,0x00,0x08,0xF9,0x08,0xF8,0x54,0x4A,0xFD,0x44,0x50,0x00,0x05,0xA4,0x09,0xF8,0x08,0xF5,0xFF,0xFF,0xFF,0xFF,0xF0,0x00,0x09,0xFD,0x0C,0xF5,0x0B,0xF4,0xCC,0xCE,0xFE,0xCC,0xC0,0x00,0x0E,0xF7,0x0F,0xF2,0x0C,0xF4,0x00,0x08,0xF8,0x00,0x00,0x00,0x3F,0xF2,0x5F,0xE0,0x0C,0xF1,0x00,0x08,0xF8,0x00,0x00,0x00,0x9F,0xD0,0xAF,0xA0,0x0F,0xF0,0x00,0x08,0xF8,0x00,0x00,0x01,0xFF,0x92,0xFF,0x30,0x1F,0xF0,0x00,0x08,0xF8,0x00,0x00,0x09,0xFF,0x3C,0xFC,0x3C,0xEF,0xC0,0x15,0x4B,0xF8,0x00,0x00,0x3F,0xFE,0x6F,0xF4,0x09,0xFF,0x90,0x0A,0xFF,0xF8,0x00,0x00,0x01,0x79,0x06,0x90,0x06,0xA5,0x00,0x05,0xFF,0xD1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x84,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0x80,0x00,0x00,0x00,0x2F,0xE8,0x10,0x00,0x00,0x00,0x01,0xDF,0xFB,0x10,0x00,0x00,0x9F,0xFF,0xF8,0x10,0x00,0x00,0x00,0x1D,0xFF,0xD3,0x00,0x00,0x02,0xAF,0xFF,0xF3,0x00,0x00,0x00,0x01,0xDF,0xD3,0x01,0x44,0x00,0x02,0xAF,0x60,0x00,0x00,0x00,0x00,0x19,0x10,0x04,0xFF,0xFF,0xFF,0xC2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFF,0xFF,0xC0,0x00,0x40,0x00,0x03,0xD4,0x00,0x00,0x00,0x00,0x00,0xCF,0xC0,0x01,0xF7,0x00,0x1F,0xFF,0x90,0x00,0x00,0x00,0x00,0xCF,0xC0,0x08,0xFF,0x60,0x03,0xFF,0xFD,0x30,0x3C,0xCC,0xC9,0xCF,0xE0,0x3F,0xFD,0x30,0x00,0x1D,0xFA,0x10,0x4F,0xFF,0xFB,0xCF,0xF7,0xFF,0xA1,0x00,0x00,0x01,0x50,0x00,0x14,0x4C,0xF8,0xCF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0D,0xF5,0xCF,0xFF,0x90,0x00,0x00,0x00,0x00,0xA6,0x10,0x00,0x2F,0xF1,0xCF,0xFF,0xF3,0x00,0x00,0x00,0x01,0xFF,0x90,0x00,0x9F,0xB0,0xCF,0xCC,0xFD,0x10,0x00,0x00,0x06,0xFF,0x20,0x03,0xFF,0x50,0xCF,0xC2,0xFF,0xD1,0x00,0x00,0x0B,0xFD,0x00,0x1D,0xFC,0x00,0xCF,0xC0,0x6F,0xFD,0x20,0x00,0x2F,0xF7,0x01,0xDF,0xF3,0x00,0xCF,0xC0,0x0A,0xFF,0xF7,0x00,0xAF,0xF2,0x6F,0xFF,0x60,0x00,0xCF,0xC0,0x00,0xAF,0xF3,0x03,0xFF,0xD0,0x4F,0xF6,0x03,0x88,0xEF,0xC0,0x00,0x0A,0x80,0x1C,0xFF,0x70,0x03,0x60,0x00,0xEF,0xFF,0xA0,0x00,0x00,0x10,0x01,0x6E,0x10,0x00,0x00,0x00,0x9F,0xFB,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x34,0x10,0x00,0x00,0x00,0x00,
							0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x14,0x44,0x44,0x44,0x44,0x41,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x28,0x88,0x88,0x8A,0xFF,0xD1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0D,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x05,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x09,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0D,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x28,0x84,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x34,0x41,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4E,0xFF,0xFF,0x91,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFC,0xEF,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0D,0xFF,0x30,0x0A,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xF9,0x00,0x01,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x72,0x00,0x02,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0A,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6C,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xF9,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x54,0x4B,0xFF,0xB0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xCF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xF4,0x00,0x00,0x8F,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xF9,0x00,0x00,0xCF,0xF1,0x00,0x00,0x00,0x00,0x00,0x00,0x0D,0xFF,0x84,0x4B,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0xFF,0xFF,0xFC,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x19,0xCC,0xCA,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x42,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x01,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF9,0xBF,0xFF,0xA2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x70,0x04,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFB,0x00,0x00,0x8F,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x4F,0xF5,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x2F,0xF7,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x5F,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFC,0x00,0x00,0xBF,0xF1,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x91,0x19,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFC,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xC7,0x8E,0xFB,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF9,0xBF,0xFF,0xA2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xA1,0x07,0xFF,0xB0,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFC,0x00,0x00,0xAF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x5F,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x4F,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x4F,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x7F,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFD,0x00,0x00,0xEF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xA3,0x3B,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF9,0x8E,0xFB,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xC6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x43,0x00,0x00,0x44,0x10,0x00,0x00,0x00,0x00,0x0F,0xFA,0xCF,0xFF,0xC1,0x6F,0xFF,0xF6,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFE,0xFF,0xFF,0xFF,0x50,0x00,0x00,0x00,0x0F,0xFF,0x70,0x1D,0xFF,0xE1,0x04,0xFF,0xB0,0x00,0x00,0x00,0x0F,0xFF,0x10,0x05,0xFF,0x90,0x00,0xCF,0xC0,0x00,0x00,0x00,0x0F,0xFC,0x00,0x04,0xFF,0x40,0x00,0xCF,0xC0,0x00,0x00,0x00,0x0F,0xF9,0x00,0x04,0xFF,0x40,0x00,0xCF,0xC0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x04,0xFF,0x40,0x00,0xCF,0xC0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x04,0xFF,0x40,0x00,0xCF,0xC0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x04,0xFF,0x40,0x00,0xCF,0xC0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x04,0xFF,0x40,0x00,0xCF,0xC0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x04,0xFF,0x40,0x00,0xCF,0xC0,0x00,0x00,0x00,0x0C,0xC6,0x00,0x03,0xCC,0x30,0x00,0x68,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_32_1_5[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x31,0x00,0x00,0x00,0x00,0x00,0x01,0xA2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0x40,0x00,0x00,0x00,0x00,0x1D,0xFF,0xB4,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xF8,0x00,0x00,0x00,0x00,0xAF,0xFF,0xFF,0xC4,0x00,0x00,0x00,0x00,0x00,0x07,0xFF,0xFF,0xB1,0x00,0x00,0x00,0x04,0xCF,0xFF,0xFF,0xE6,0x00,0x00,0x00,0x00,0x00,0x6F,0xFF,0xFD,0x10,0x00,0x00,0x00,0x02,0xCF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xE3,0x00,0x04,0x44,0x44,0x44,0x48,0xEF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x6D,0x10,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x44,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x00,0x0C,0xC8,0x88,0x8F,0xFF,0x40,0x00,0x0B,0x10,0x00,0x00,0xAF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x40,0x00,0x6F,0xC0,0x00,0x0C,0xFF,0xFC,0x20,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x40,0x01,0xFF,0xFA,0x00,0x04,0xFF,0xFF,0xF6,0x00,0x04,0x88,0x88,0x88,0x2F,0xFF,0x50,0x09,0xFF,0xFD,0x20,0x00,0x1D,0xFF,0xFF,0x60,0x08,0xFF,0xFF,0xFF,0x4F,0xFF,0xC0,0x5F,0xFF,0xA1,0x00,0x00,0x00,0xAF,0xF6,0x00,0x08,0xFF,0xFF,0xFF,0x3F,0xFF,0xF7,0xFF,0xF6,0x00,0x00,0x00,0x00,0x09,0x30,0x00,0x02,0x44,0x4D,0xFF,0x0F,0xFF,0xFF,0xFD,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFD,0x0F,0xFF,0xFF,0xB0,0x00,0x00,0x00,0x00,0x00,0x02,0x10,0x00,0x00,0x00,0x4F,0xFA,0x0F,0xFF,0xFF,0xE1,0x00,0x00,0x00,0x00,0x00,0x06,0xE6,0x10,0x00,0x00,0x9F,0xF6,0x0F,0xFF,0xFF,0xFA,0x00,0x00,0x00,0x00,0x00,0x0A,0xFF,0xC0,0x00,0x01,0xFF,0xF1,0x0F,0xFF,0x6F,0xFF,0x60,0x00,0x00,0x00,0x00,0x0F,0xFF,0x60,0x00,0x08,0xFF,0xA0,0x0F,0xFF,0x48,0xFF,0xF3,0x00,0x00,0x00,0x00,0x5F,0xFF,0x10,0x00,0x3F,0xFF,0x20,0x0F,0xFF,0x40,0xDF,0xFF,0x40,0x00,0x00,0x00,0xAF,0xFB,0x00,0x01,0xFF,0xFA,0x00,0x0F,0xFF,0x40,0x2F,0xFF,0xF7,0x00,0x00,0x01,0xFF,0xF6,0x00,0x2D,0xFF,0xF1,0x00,0x0F,0xFF,0x40,0x04,0xFF,0xFF,0xD4,0x00,0x08,0xFF,0xF0,0x05,0xFF,0xFF,0x50,0x00,0x0F,0xFF,0x40,0x00,0x6F,0xFF,0xF4,0x00,0x1F,0xFF,0xA0,0xAF,0xFF,0xF7,0x00,0x00,0x0F,0xFF,0x40,0x00,0x06,0xFF,0x70,0x00,0xBF,0xFF,0x50,0x1A,0xFF,0x80,0x05,0xA8,0xAF,0xFF,0x40,0x00,0x00,0x6E,0x00,0x07,0xFF,0xFF,0x00,0x00,0xA6,0x00,0x00,0xFF,0xFF,0xFF,0x30,0x00,0x00,0x01,0x00,0x03,0x9F,0xFA,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x64,0x00,0x00,0x00,0x00,0x00,0x4F,0xFB,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x14,0x44,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x39,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xD2,0x00,0x00,0x00,0x00,0x00,0x1F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x1D,0xFF,0xFF,0x40,0x00,0x00,0x00,0x00,0x0F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xBF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x0F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0A,0xFF,0xFF,0x30,0x9C,0xC9,0x00,0x0F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xC1,0x00,0xBF,0xF8,0x00,0x0F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0x00,0x00,0x8F,0xF8,0x00,0x0F,0xFF,0x00,0x01,0x6B,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xF8,0x00,0x0F,0xFF,0x27,0xBF,0xFF,0x80,0x00,0x00,0x08,0x20,0x00,0x00,0x00,0x8F,0xF8,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x01,0xAF,0xF7,0x00,0x00,0x00,0x8F,0xF8,0x39,0xDF,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x06,0xFF,0xFF,0xC2,0x00,0x00,0x8F,0xFF,0xFF,0xFF,0xFF,0xD7,0x2C,0xFF,0x80,0x00,0x00,0x4F,0xFF,0xFF,0x50,0x5A,0xFF,0xFF,0xFF,0xFF,0xFF,0x00,0x0C,0xFF,0x80,0x00,0x00,0x03,0xDF,0xFF,0x7F,0xFF,0xFF,0xFF,0xD7,0x2F,0xFF,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x1D,0xD2,0x0D,0xFF,0xFF,0xF8,0x00,0x0F,0xFF,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x01,0x10,0x08,0xD7,0xAF,0xF8,0x00,0x0F,0xFF,0x00,0x08,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x8F,0xF8,0x00,0x0F,0xFF,0x00,0x08,0xFF,0x80,0x00,0x00,0x00,0x00,0xB1,0x00,0x00,0x8F,0xF8,0x00,0x0F,0xFF,0x00,0x09,0xFF,0x80,0x00,0x00,0x00,0x04,0xFF,0xB1,0x00,0x8F,0xF8,0x00,0x0F,0xFF,0x68,0xCF,0xFF,0x80,0x00,0x00,0x00,0x09,0xFF,0xD0,0x00,0x8F,0xF8,0x00,0x0F,0xFF,0x3F,0xFF,0xFF,0x20,0x00,0x00,0x00,0x0E,0xFF,0x70,0x00,0x8F,0xF8,0x00,0x0F,0xFF,0x0A,0xFF,0xF6,0x00,0x00,0x00,0x00,0x3F,0xFF,0x20,0x00,0x8F,0xF8,0x00,0x4F,0xFF,0x04,0x85,0x10,0x00,0x00,0x00,0x00,0xAF,0xFD,0x00,0x00,0x8F,0xF8,0x00,0x4F,0xFF,0x20,0x00,0x04,0x10,0x00,0x00,0x01,0xFF,0xF7,0x00,0x00,0x8F,0xF8,0x00,0x5F,0xFF,0x40,0x00,0x09,0xF8,0x20,0x00,0x08,0xFF,0xF2,0x00,0x00,0x8F,0xF8,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF3,0x00,0x2F,0xFF,0xB0,0x00,0x00,0x8F,0xFE,0x20,0x00,0x00,0x00,0x00,0x2F,0xFF,0xE0,0x01,0xDF,0xFF,0x60,0x00,0x00,0x7F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x80,0x03,0xBF,0xFF,0x10,0x00,0x00,0x2F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x10,0x00,0x02,0x8A,0x00,0x00,0x00,0x05,0xEF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xD3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x00,0x00,0x01,0x50,0x00,0x00,0x02,0x8C,0x60,0x00,0x00,0x00,0xED,0x73,0x00,0x00,0x00,0x00,0x1D,0xF9,0x00,0x00,0x04,0xFF,0xC0,0x00,0x00,0x02,0xFF,0xF3,0x00,0x00,0x00,0x00,0xBF,0xFF,0xA1,0x00,0x00,0xEF,0xF2,0x00,0x00,0x07,0xFF,0xA0,0x00,0x00,0x00,0x00,0x1D,0xFF,0xFD,0x10,0x00,0x9F,0xF7,0x00,0x00,0x0D,0xFF,0x30,0x00,0x00,0x00,0x00,0x01,0xDF,0xFF,0xC0,0x00,0x4B,0x73,0x00,0x00,0x2F,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x1D,0xFD,0xEC,0xCC,0xCC,0xCC,0xCC,0x40,0xAF,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x01,0x91,0xFF,0xFF,0xFF,0xFF,0xFF,0x42,0xFF,0xD8,0x88,0x88,0x8B,0x60,0x00,0x00,0x00,0x00,0xFF,0xFF,0xFF,0xFF,0xFF,0x4B,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x8F,0xF0,0x00,0x00,0x5F,0xFC,0x00,0x00,0x00,0x00,0x00,0x03,0xFD,0x20,0x00,0x00,0x8F,0xF0,0x00,0x03,0xFF,0xFC,0x88,0x88,0x88,0x88,0x20,0x1F,0xFF,0xF5,0x00,0x00,0x8F,0xF0,0x00,0x1E,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x40,0x06,0xFF,0xFF,0x90,0x00,0x8F,0xFF,0xFF,0xFF,0xAF,0x5C,0x98,0x88,0xFF,0xFF,0x30,0x00,0x3F,0xFF,0xF7,0x00,0xBF,0xFF,0xFF,0xFF,0x41,0x00,0x00,0x0A,0xFF,0xD2,0x00,0x00,0x03,0xFF,0x60,0x00,0xCF,0xF8,0x8C,0xFF,0x10,0x00,0x00,0x9F,0xFD,0x10,0x00,0x00,0x00,0x33,0x00,0x00,0xCF,0xF0,0x08,0xFF,0x00,0x00,0x06,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xEF,0xC0,0x0C,0xFF,0x00,0x00,0x0D,0xFF,0x70,0x00,0x00,0x00,0x00,0x03,0x00,0x00,0xFF,0xC0,0x0C,0xFE,0x4C,0xA8,0x8E,0xFF,0xA8,0xAC,0xA0,0x00,0x00,0x2F,0xA4,0x02,0xFF,0xA0,0x0C,0xFC,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x6F,0xFC,0x05,0xFF,0x80,0x0C,0xFC,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0xBF,0xF7,0x09,0xFF,0x40,0x0F,0xFB,0x11,0x00,0x0C,0xFF,0x40,0x00,0x30,0x00,0x00,0xFF,0xF2,0x0D,0xFF,0x10,0x0F,0xF8,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x00,0x05,0xFF,0xD0,0x2F,0xFD,0x00,0x0F,0xF8,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x00,0x0B,0xFF,0x70,0x8F,0xF8,0x00,0x4F,0xF6,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x00,0x2F,0xFF,0x31,0xFF,0xF2,0x00,0x4F,0xF4,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x00,0xAF,0xFE,0x08,0xFF,0xC4,0x31,0xAF,0xF4,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x03,0xFF,0xF9,0x3F,0xFF,0x41,0xFF,0xFF,0xF0,0x02,0x74,0x5E,0xFF,0x40,0x00,0x00,0x1D,0xFF,0xF5,0xDF,0xFC,0x00,0x8F,0xFF,0xE0,0x00,0xAF,0xFF,0xFF,0x10,0x00,0x00,0x03,0xAF,0xF0,0x3E,0xF3,0x00,0x4F,0xFB,0x20,0x00,0x3F,0xFF,0xFC,0x00,0x00,0x00,0x00,0x01,0x50,0x01,0x60,0x00,0x14,0x00,0x00,0x00,0x0F,0xFF,0xA1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x31,0x00,0x00,0x00,0x00,0x00,0x01,0xA2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0x40,0x00,0x00,0x00,0x00,0x1D,0xFF,0xB4,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xF8,0x00,0x00,0x00,0x00,0xAF,0xFF,0xFF,0xC4,0x00,0x00,0x00,0x00,0x00,0x07,0xFF,0xFF,0xB1,0x00,0x00,0x00,0x04,0xCF,0xFF,0xFF,0xE6,0x00,0x00,0x00,0x00,0x00,0x6F,0xFF,0xFD,0x10,0x00,0x00,0x00,0x02,0xCF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xE3,0x00,0x04,0x44,0x44,0x44,0x48,0xEF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x6D,0x10,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x44,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x00,0x0C,0xC8,0x88,0x8F,0xFF,0x40,0x00,0x0B,0x10,0x00,0x00,0xAF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x40,0x00,0x6F,0xC0,0x00,0x0C,0xFF,0xFC,0x20,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x40,0x01,0xFF,0xFA,0x00,0x04,0xFF,0xFF,0xF6,0x00,0x04,0x88,0x88,0x88,0x2F,0xFF,0x50,0x09,0xFF,0xFD,0x20,0x00,0x1D,0xFF,0xFF,0x60,0x08,0xFF,0xFF,0xFF,0x4F,0xFF,0xC0,0x5F,0xFF,0xA1,0x00,0x00,0x00,0xAF,0xF6,0x00,0x08,0xFF,0xFF,0xFF,0x3F,0xFF,0xF7,0xFF,0xF6,0x00,0x00,0x00,0x00,0x09,0x30,0x00,0x02,0x44,0x4D,0xFF,0x0F,0xFF,0xFF,0xFD,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFD,0x0F,0xFF,0xFF,0xB0,0x00,0x00,0x00,0x00,0x00,0x02,0x10,0x00,0x00,0x00,0x4F,0xFA,0x0F,0xFF,0xFF,0xE1,0x00,0x00,0x00,0x00,0x00,0x06,0xE6,0x10,0x00,0x00,0x9F,0xF6,0x0F,0xFF,0xFF,0xFA,0x00,0x00,0x00,0x00,0x00,0x0A,0xFF,0xC0,0x00,0x01,0xFF,0xF1,0x0F,0xFF,0x6F,0xFF,0x60,0x00,0x00,0x00,0x00,0x0F,0xFF,0x60,0x00,0x08,0xFF,0xA0,0x0F,0xFF,0x48,0xFF,0xF3,0x00,0x00,0x00,0x00,0x5F,0xFF,0x10,0x00,0x3F,0xFF,0x20,0x0F,0xFF,0x40,0xDF,0xFF,0x40,0x00,0x00,0x00,0xAF,0xFB,0x00,0x01,0xFF,0xFA,0x00,0x0F,0xFF,0x40,0x2F,0xFF,0xF7,0x00,0x00,0x01,0xFF,0xF6,0x00,0x2D,0xFF,0xF1,0x00,0x0F,0xFF,0x40,0x04,0xFF,0xFF,0xD4,0x00,0x08,0xFF,0xF0,0x05,0xFF,0xFF,0x50,0x00,0x0F,0xFF,0x40,0x00,0x6F,0xFF,0xF4,0x00,0x1F,0xFF,0xA0,0xAF,0xFF,0xF7,0x00,0x00,0x0F,0xFF,0x40,0x00,0x06,0xFF,0x70,0x00,0xBF,0xFF,0x50,0x1A,0xFF,0x80,0x05,0xA8,0xAF,0xFF,0x40,0x00,0x00,0x6E,0x00,0x07,0xFF,0xFF,0x00,0x00,0xA6,0x00,0x00,0xFF,0xFF,0xFF,0x30,0x00,0x00,0x01,0x00,0x03,0x9F,0xFA,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x64,0x00,0x00,0x00,0x00,0x00,0x4F,0xFB,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
							0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x09,0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x88,0x88,0x88,0x88,0xCF,0xFF,0xB0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xFD,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0D,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0B,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xBF,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xFF,0xD0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x2F,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7F,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xDF,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xFF,0xF7,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6D,0xFF,0xFE,0x91,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1D,0xFF,0xFF,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xCF,0xFF,0xEB,0xDF,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0xFA,0x00,0x05,0xFF,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0B,0xFF,0xE0,0x00,0x00,0x9F,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xFF,0x80,0x00,0x00,0x8F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x30,0x00,0x00,0x9F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xFB,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x34,0x9F,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xFF,0xFF,0xE3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x74,0x59,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x5F,0xFF,0xA0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4C,0xFF,0x40,0x00,0x00,0x08,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x2F,0xFF,0x90,0x00,0x00,0x0D,0xFF,0xD0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0D,0xFF,0xF2,0x00,0x00,0x6F,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x05,0xFF,0xFE,0x64,0x5A,0xFF,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xFF,0xFF,0xFF,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xFF,0xFF,0xFA,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x15,0x88,0x84,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x27,0x88,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x9A,0xFF,0xFF,0xFE,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xA4,0x48,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF8,0x00,0x00,0x3F,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xE0,0x00,0x00,0x0A,0xFF,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x05,0xFF,0xF1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x04,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x01,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x04,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x90,0x00,0x00,0x05,0xFF,0xF1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xD0,0x00,0x00,0x0A,0xFF,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF4,0x00,0x00,0x4F,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0x61,0x16,0xFF,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xBD,0xFF,0xFF,0xFC,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x44,0x20,0x48,0x87,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x88,0x40,0x27,0x88,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x9A,0xFF,0xFF,0xFC,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xB5,0x4A,0xFF,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFA,0x00,0x00,0x6F,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xE0,0x00,0x00,0x0D,0xFF,0xD0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x90,0x00,0x00,0x08,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x04,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x04,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x06,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xA0,0x00,0x00,0x09,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xE0,0x00,0x00,0x0E,0xFF,0xD0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF7,0x00,0x00,0x7F,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0x84,0x48,0xFF,0xFE,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xBD,0xFF,0xFF,0xFC,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x48,0x86,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x09,0xCC,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x88,0x60,0x4A,0xCB,0x71,0x00,0x06,0xAC,0x94,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xDC,0xFF,0xFF,0xFE,0x33,0xDF,0xFF,0xFF,0xC1,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xFF,0xFF,0xFF,0xFF,0xEF,0xFF,0xFF,0xFF,0xFB,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xFF,0x74,0x6E,0xFF,0xFF,0xE5,0x47,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x08,0xFF,0xF9,0x00,0x01,0xFF,0xFF,0x50,0x00,0x4F,0xFF,0x70,0x00,0x00,0x00,0x00,0x08,0xFF,0xF5,0x00,0x00,0xCF,0xFF,0x10,0x00,0x0E,0xFF,0x80,0x00,0x00,0x00,0x00,0x08,0xFF,0xF0,0x00,0x00,0xCF,0xFC,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x08,0xFF,0xE0,0x00,0x00,0xCF,0xFC,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x08,0xFF,0xC0,0x00,0x00,0xCF,0xFC,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x08,0xFF,0xC0,0x00,0x00,0xCF,0xFC,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x08,0xFF,0xC0,0x00,0x00,0xCF,0xFC,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x08,0xFF,0xC0,0x00,0x00,0xCF,0xFC,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x08,0xFF,0xC0,0x00,0x00,0xCF,0xFC,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x08,0xFF,0xC0,0x00,0x00,0xCF,0xFC,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x08,0xFF,0xC0,0x00,0x00,0xCF,0xFC,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x08,0xFF,0xC0,0x00,0x00,0xCF,0xFC,0x00,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x04,0x88,0x60,0x00,0x00,0x34,0x43,0x00,0x00,0x03,0x44,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};

const uint8_t t_16_2[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xA2,0x00,0x00,0x4C,0x50,0x00,0x00,0x08,0xFF,0x40,0x00,0x9F,0xFE,0x60,0x00,0x00,0x8F,0xD1,0x24,0x45,0xDF,0x60,0x00,0x00,0x05,0x00,0x8F,0xFF,0xF5,0x01,0x00,0x08,0x30,0x00,0x46,0x4A,0xF4,0x0A,0x30,0x5F,0xF7,0x01,0x44,0x49,0xF4,0x3F,0xF1,0x05,0xFD,0x34,0xFF,0xFC,0xFB,0xDF,0x40,0x00,0x31,0x01,0x4A,0xF8,0xFF,0xB1,0x00,0x00,0x36,0x00,0x0D,0xD8,0xFF,0xC0,0x00,0x00,0x7F,0x60,0x4F,0x78,0xFC,0xF8,0x00,0x00,0xDF,0x11,0xDF,0x18,0xF4,0xDF,0x80,0x04,0xFA,0x2D,0xF7,0x08,0xF4,0x1F,0xFA,0x0C,0xF5,0xAF,0xA2,0x5B,0xF4,0x03,0xF2,0x4E,0xF0,0x05,0x00,0xEF,0xF2,0x00,0x10,0x00,0x40,0x00,0x00,0x68,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x40,0x00,0x00,0x01,0xC5,0x00,0x00,0x0B,0xF0,0x00,0x00,0x06,0xFF,0x80,0x00,0x08,0xF0,0x00,0x00,0x00,0x3F,0xB1,0xFE,0x08,0xF0,0x00,0x00,0x00,0x03,0x00,0xCC,0x08,0xF3,0x9E,0x40,0x0A,0x80,0x00,0xCC,0x4C,0xFF,0xFF,0x40,0x3E,0xFC,0x25,0xEF,0xFF,0xF6,0x9F,0x40,0x01,0xDC,0x9F,0xFE,0x69,0xF0,0x8F,0x40,0x00,0x10,0x36,0xDC,0x08,0xF0,0x4F,0x40,0x00,0x2B,0x40,0xCC,0x08,0xF5,0xBF,0x40,0x00,0x7F,0x60,0xCC,0x09,0xF8,0xFE,0x10,0x00,0xDF,0x10,0xCC,0x0C,0xF3,0x42,0x00,0x04,0xFB,0x00,0xCC,0x06,0x82,0x07,0xE7,0x1D,0xF6,0x00,0xCF,0x98,0x88,0x8D,0xF7,0x17,0xE1,0x00,0x7F,0xFF,0xFF,0xFF,0xD1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x03,0x90,0x03,0xD6,0x00,0x1F,0x90,0x00,0x0C,0xFB,0x10,0xEB,0x00,0x6F,0x40,0x00,0x00,0xBF,0xC8,0xDC,0x80,0xCF,0xFF,0xF4,0x00,0x13,0xFF,0xFF,0xF4,0xF8,0x44,0x52,0x19,0x10,0x0C,0x80,0x1E,0xF4,0x44,0x41,0x7F,0xE3,0x0C,0xC8,0xDF,0xFC,0xCF,0xF4,0x06,0xF8,0x0F,0xED,0xF4,0x00,0xAF,0x60,0x00,0x20,0x0F,0x85,0xF0,0x07,0xF7,0x00,0x00,0x63,0x1F,0x78,0xFC,0xDE,0xFD,0xF4,0x00,0xDE,0x5F,0x48,0xF8,0x8C,0xFA,0x83,0x02,0xF9,0x9F,0x08,0xC0,0x08,0xF4,0x00,0x08,0xF3,0xFB,0x0C,0xC0,0x08,0xF4,0x00,0x1F,0xF8,0xF7,0xCF,0xA1,0x4A,0xF4,0x00,0x6E,0xBC,0xC0,0xBF,0x50,0xCF,0xF0,0x00,0x00,0x20,0x20,0x20,0x00,0x6A,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xA2,0x00,0x00,0x4C,0x50,0x00,0x00,0x08,0xFF,0x40,0x00,0x9F,0xFE,0x60,0x00,0x00,0x8F,0xD1,0x24,0x45,0xDF,0x60,0x00,0x00,0x05,0x00,0x8F,0xFF,0xF5,0x01,0x00,0x08,0x30,0x00,0x46,0x4A,0xF4,0x0A,0x30,0x5F,0xF7,0x01,0x44,0x49,0xF4,0x3F,0xF1,0x05,0xFD,0x34,0xFF,0xFC,0xFB,0xDF,0x40,0x00,0x31,0x01,0x4A,0xF8,0xFF,0xB1,0x00,0x00,0x36,0x00,0x0D,0xD8,0xFF,0xC0,0x00,0x00,0x7F,0x60,0x4F,0x78,0xFC,0xF8,0x00,0x00,0xDF,0x11,0xDF,0x18,0xF4,0xDF,0x80,0x04,0xFA,0x2D,0xF7,0x08,0xF4,0x1F,0xFA,0x0C,0xF5,0xAF,0xA2,0x5B,0xF4,0x03,0xF2,0x4E,0xF0,0x05,0x00,0xEF,0xF2,0x00,0x10,0x00,0x40,0x00,0x00,0x68,0x20,0x00,0x00,
							0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x48,0x88,0x88,0x84,0x00,0x00,0x00,0x00,0x8F,0xFF,0xFF,0xF8,0x00,0x00,0x00,0x00,0x24,0x44,0x5F,0xF5,0x00,0x00,0x00,0x00,0x00,0x00,0xBF,0x80,0x00,0x00,0x00,0x00,0x00,0x04,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xD0,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0xEF,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x68,0x84,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x6F,0xB0,0x2F,0xF0,0x00,0x00,0x00,0x00,0x4A,0x40,0x0D,0xF0,0x00,0x00,0x00,0x00,0x00,0x04,0x8F,0xD0,0x00,0x00,0x00,0x00,0x00,0x1F,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x24,0x5E,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xF8,0x00,0x00,0x00,0x00,0xBF,0x50,0x07,0xF8,0x00,0x00,0x00,0x00,0x6F,0xD4,0x5F,0xF4,0x00,0x00,0x00,0x00,0x0A,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x24,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6C,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0x7B,0xC9,0x10,0x00,0x00,0x00,0x00,0x8F,0xFD,0xCF,0xD1,0x00,0x00,0x00,0x00,0x8F,0xB0,0x08,0xF7,0x00,0x00,0x00,0x00,0x8F,0x40,0x04,0xFB,0x00,0x00,0x00,0x00,0x8F,0x40,0x04,0xFC,0x00,0x00,0x00,0x00,0x8F,0x60,0x05,0xF8,0x00,0x00,0x00,0x00,0x8F,0xE3,0x3D,0xF4,0x00,0x00,0x00,0x00,0x8F,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x24,0x14,0x41,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6C,0x6B,0xC9,0x10,0x00,0x00,0x00,0x00,0x8F,0xFD,0xDF,0xD1,0x00,0x00,0x00,0x00,0x8F,0xB0,0x0A,0xF6,0x00,0x00,0x00,0x00,0x8F,0x40,0x04,0xFA,0x00,0x00,0x00,0x00,0x8F,0x40,0x04,0xFB,0x00,0x00,0x00,0x00,0x8F,0x70,0x07,0xF8,0x00,0x00,0x00,0x00,0x8F,0xE4,0x5F,0xF3,0x00,0x00,0x00,0x00,0x8F,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x8F,0x44,0x41,0x00,0x00,0x00,0x00,0x00,0x8F,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x6C,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x9D,0xFA,0x2A,0xFD,0x40,0x00,0x00,0x4F,0xFC,0xEF,0xFE,0xCF,0xF1,0x00,0x00,0x4F,0xC0,0x1F,0xF3,0x0A,0xF4,0x00,0x00,0x4F,0x90,0x0F,0xF0,0x08,0xF4,0x00,0x00,0x4F,0x80,0x0F,0xF0,0x08,0xF4,0x00,0x00,0x4F,0x80,0x0F,0xF0,0x08,0xF4,0x00,0x00,0x4F,0x80,0x0F,0xF0,0x08,0xF4,0x00,0x00,0x4F,0x80,0x0F,0xF0,0x08,0xF4,0x00,0x00,0x14,0x20,0x04,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_24_2[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x03,0x10,0x00,0x00,0x00,0x00,0x00,0x3F,0xA1,0x00,0x00,0x00,0x3F,0xFA,0x20,0x00,0x00,0x00,0x01,0xEF,0xFD,0x20,0x00,0x00,0xBF,0xFF,0xFA,0x20,0x00,0x00,0x00,0x3F,0xFF,0xF4,0x00,0x00,0x04,0xCF,0xFF,0xF5,0x00,0x00,0x00,0x02,0xDF,0xD3,0x01,0x44,0x44,0x48,0xFF,0x60,0x00,0x00,0x00,0x00,0x2B,0x10,0x04,0xFF,0xFF,0xFF,0xC4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFF,0xFF,0xC0,0x00,0x60,0x00,0x03,0xE5,0x00,0x00,0x01,0x00,0x00,0xCF,0xC0,0x02,0xF8,0x00,0x3F,0xFF,0xB1,0x00,0x00,0x00,0x00,0xCF,0xC0,0x0A,0xFF,0x60,0x06,0xFF,0xFF,0x40,0x4F,0xFF,0xFC,0xCF,0xF1,0x4F,0xFF,0x60,0x00,0x3F,0xFA,0x10,0x4F,0xFF,0xFC,0xCF,0xFA,0xFF,0xD2,0x00,0x00,0x01,0x60,0x00,0x14,0x4D,0xF9,0xCF,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF6,0xCF,0xFF,0xA0,0x00,0x00,0x00,0x00,0xC6,0x10,0x00,0x4F,0xF2,0xCF,0xFF,0xF4,0x00,0x00,0x00,0x02,0xFF,0xA0,0x00,0xAF,0xD0,0xCF,0xDE,0xFF,0x10,0x00,0x00,0x07,0xFF,0x50,0x04,0xFF,0x60,0xCF,0xC4,0xFF,0xD1,0x00,0x00,0x0D,0xFF,0x00,0x1F,0xFE,0x00,0xCF,0xC0,0x8F,0xFF,0x40,0x00,0x3F,0xFA,0x03,0xEF,0xF5,0x00,0xCF,0xC0,0x0B,0xFF,0xF9,0x00,0xBF,0xF3,0x8F,0xFF,0x90,0x00,0xCF,0xC0,0x01,0xDF,0xF3,0x05,0xFF,0xE0,0x4F,0xFA,0x04,0x88,0xFF,0xC0,0x00,0x1D,0x80,0x1F,0xFF,0x90,0x03,0x80,0x00,0xEF,0xFF,0xC0,0x00,0x00,0x10,0x01,0x6E,0x30,0x00,0x00,0x00,0x9F,0xFE,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x37,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x10,0x00,0x00,0x00,0x00,0xCC,0x90,0x00,0x00,0x00,0x00,0x3F,0xF4,0x00,0x00,0x00,0x00,0xFF,0x80,0x00,0x00,0x00,0x00,0xAF,0xFF,0x80,0x00,0x00,0x00,0xFF,0x80,0x00,0x00,0x00,0x00,0x0A,0xFF,0xF9,0x08,0x88,0x00,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0xAF,0xC1,0x0D,0xFC,0x00,0xFF,0x80,0x00,0x01,0x00,0x00,0x00,0x06,0x00,0x0C,0xFC,0x00,0xFF,0x80,0x39,0xD8,0x00,0x00,0x31,0x00,0x00,0x0C,0xFC,0x00,0xFF,0xDE,0xFF,0xF8,0x00,0x04,0xFD,0x30,0x00,0x0C,0xFC,0x5A,0xFF,0xFF,0xFF,0xF8,0x00,0x1D,0xFF,0xF8,0x00,0x1D,0xFF,0xFF,0xFF,0xE7,0x2F,0xF8,0x00,0x00,0xAF,0xFF,0xBB,0xFF,0xFF,0xFD,0xFF,0x80,0x0F,0xF8,0x00,0x00,0x06,0xF6,0x3F,0xFF,0xFD,0x20,0xFF,0x80,0x0F,0xF8,0x00,0x00,0x00,0x20,0x0C,0x7D,0xFC,0x00,0xFF,0x80,0x0F,0xF8,0x00,0x00,0x00,0x30,0x00,0x0C,0xFC,0x00,0xFF,0x80,0x0F,0xF8,0x00,0x00,0x00,0xDE,0x80,0x0C,0xFC,0x00,0xFF,0xB8,0xCF,0xF8,0x00,0x00,0x01,0xFF,0xB0,0x0C,0xFC,0x00,0xFF,0x8D,0xFF,0xF3,0x00,0x00,0x06,0xFF,0x60,0x0C,0xFC,0x00,0xFF,0x97,0xFB,0x40,0x00,0x00,0x0C,0xFF,0x00,0x0C,0xFC,0x00,0xFF,0xC0,0x00,0x41,0x00,0x00,0x4F,0xFA,0x00,0x0C,0xFC,0x02,0xCC,0x90,0x00,0x8F,0x92,0x00,0xCF,0xF5,0x00,0x0C,0xFD,0x00,0x00,0x00,0x00,0xDF,0xF7,0x07,0xFF,0xF0,0x00,0x0B,0xFF,0xFE,0xFF,0xFF,0xFF,0xFF,0xF2,0x06,0xDF,0xA0,0x00,0x06,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x90,0x00,0x04,0x30,0x00,0x00,0x68,0x88,0x88,0x88,0x88,0x87,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x02,0x40,0x00,0x00,0x67,0x20,0x00,0x00,0x00,0xAF,0x30,0x00,0x6F,0xF2,0x00,0x00,0xBF,0xF2,0x00,0x00,0x04,0xFF,0xF6,0x00,0x0F,0xF8,0x00,0x00,0xFF,0x80,0x00,0x00,0x00,0x6F,0xFF,0x60,0x0A,0xFA,0x00,0x06,0xFF,0x98,0x88,0x80,0x00,0x06,0xFF,0xF8,0x8A,0x88,0xB9,0x0C,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x71,0xFF,0xFF,0xFF,0xFC,0x4F,0xF8,0x88,0x88,0x60,0x00,0x00,0x00,0xBA,0xFE,0x88,0x99,0xDF,0xA0,0x00,0x00,0x00,0x07,0xD2,0x00,0x04,0xFC,0x00,0x0A,0xFF,0xA8,0x88,0x88,0x80,0x7F,0xFF,0x60,0x04,0xFD,0x44,0x9F,0xFF,0xFF,0xFF,0xFF,0xF0,0x06,0xFF,0xF9,0x04,0xFF,0xFF,0xFC,0x94,0x44,0x4D,0xFF,0x90,0x00,0x6F,0xD1,0x05,0xFF,0xCE,0xFC,0x00,0x00,0xAF,0xF3,0x00,0x00,0x04,0x00,0x08,0xFC,0x08,0xF9,0x00,0x0A,0xFF,0x50,0x00,0x00,0x01,0x00,0x08,0xFC,0x08,0xF8,0x84,0x4D,0xFE,0x45,0x80,0x00,0x07,0xA4,0x0C,0xF8,0x0C,0xF8,0xFF,0xFF,0xFF,0xFF,0xF0,0x00,0x0B,0xFE,0x0E,0xF7,0x0C,0xF6,0xFD,0xCE,0xFF,0xCF,0xF0,0x00,0x0F,0xF9,0x2F,0xF4,0x0C,0xF4,0x00,0x08,0xFC,0x00,0x00,0x00,0x5F,0xF4,0x6F,0xF0,0x0E,0xF4,0x00,0x08,0xFC,0x00,0x00,0x00,0xAF,0xF0,0xDF,0xB0,0x0F,0xF2,0x00,0x08,0xFC,0x00,0x00,0x02,0xFF,0xA4,0xFF,0x70,0x1F,0xF0,0x00,0x08,0xFC,0x00,0x00,0x0B,0xFF,0x6E,0xFE,0x3F,0xFF,0xF0,0x36,0x4D,0xFC,0x00,0x00,0x3F,0xFF,0x8F,0xF5,0x0A,0xFF,0xA0,0x0A,0xFF,0xFA,0x00,0x00,0x01,0x7A,0x06,0xB0,0x06,0xC7,0x00,0x05,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x01,0x87,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x03,0x10,0x00,0x00,0x00,0x00,0x00,0x3F,0xA1,0x00,0x00,0x00,0x3F,0xFA,0x20,0x00,0x00,0x00,0x01,0xEF,0xFD,0x20,0x00,0x00,0xBF,0xFF,0xFA,0x20,0x00,0x00,0x00,0x3F,0xFF,0xF4,0x00,0x00,0x04,0xCF,0xFF,0xF5,0x00,0x00,0x00,0x02,0xDF,0xD3,0x01,0x44,0x44,0x48,0xFF,0x60,0x00,0x00,0x00,0x00,0x2B,0x10,0x04,0xFF,0xFF,0xFF,0xC4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFF,0xFF,0xC0,0x00,0x60,0x00,0x03,0xE5,0x00,0x00,0x01,0x00,0x00,0xCF,0xC0,0x02,0xF8,0x00,0x3F,0xFF,0xB1,0x00,0x00,0x00,0x00,0xCF,0xC0,0x0A,0xFF,0x60,0x06,0xFF,0xFF,0x40,0x4F,0xFF,0xFC,0xCF,0xF1,0x4F,0xFF,0x60,0x00,0x3F,0xFA,0x10,0x4F,0xFF,0xFC,0xCF,0xFA,0xFF,0xD2,0x00,0x00,0x01,0x60,0x00,0x14,0x4D,0xF9,0xCF,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF6,0xCF,0xFF,0xA0,0x00,0x00,0x00,0x00,0xC6,0x10,0x00,0x4F,0xF2,0xCF,0xFF,0xF4,0x00,0x00,0x00,0x02,0xFF,0xA0,0x00,0xAF,0xD0,0xCF,0xDE,0xFF,0x10,0x00,0x00,0x07,0xFF,0x50,0x04,0xFF,0x60,0xCF,0xC4,0xFF,0xD1,0x00,0x00,0x0D,0xFF,0x00,0x1F,0xFE,0x00,0xCF,0xC0,0x8F,0xFF,0x40,0x00,0x3F,0xFA,0x03,0xEF,0xF5,0x00,0xCF,0xC0,0x0B,0xFF,0xF9,0x00,0xBF,0xF3,0x8F,0xFF,0x90,0x00,0xCF,0xC0,0x01,0xDF,0xF3,0x05,0xFF,0xE0,0x4F,0xFA,0x04,0x88,0xFF,0xC0,0x00,0x1D,0x80,0x1F,0xFF,0x90,0x03,0x80,0x00,0xEF,0xFF,0xC0,0x00,0x00,0x10,0x01,0x6E,0x30,0x00,0x00,0x00,0x9F,0xFE,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x37,0x30,0x00,0x00,0x00,0x00,
							0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x14,0x44,0x44,0x44,0x44,0x42,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x28,0x88,0x88,0x8B,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1E,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xBF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xD0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xCF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1F,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFB,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0xC6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x48,0x72,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFF,0xFF,0xC1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x05,0xFF,0xFD,0xFF,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xFF,0x40,0x1B,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFA,0x00,0x04,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x24,0x85,0x00,0x04,0xFF,0xA0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1D,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6C,0xFF,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xCF,0xFF,0xFC,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x74,0x5C,0xFF,0xD0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xEF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x8F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x9F,0xF5,0x00,0x00,0x9F,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFC,0x00,0x01,0xEF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xFF,0xB4,0x6D,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFF,0xFF,0xFD,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3A,0xEF,0xEB,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x28,0x84,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF8,0x02,0x42,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFB,0xCF,0xFF,0xC3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xB1,0x07,0xFF,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFC,0x00,0x00,0xAF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF8,0x00,0x00,0x5F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF8,0x00,0x00,0x4F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF8,0x00,0x00,0x4F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF8,0x00,0x00,0x7F,0xF7,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFE,0x00,0x00,0xEF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xB4,0x4B,0xFF,0xB0,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFD,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0xC7,0xAF,0xFD,0x71,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x42,0x02,0x41,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFB,0xCF,0xFF,0xC3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xB2,0x29,0xFF,0xD0,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFE,0x10,0x00,0xDF,0xF3,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x8F,0xF7,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x4F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x6F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF9,0x00,0x00,0x9F,0xF5,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFE,0x00,0x01,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xB4,0x5D,0xFF,0xA0,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFD,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF9,0xAF,0xFD,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xC6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x42,0x04,0x85,0x00,0x02,0x56,0x20,0x00,0x00,0x00,0x00,0x0F,0xFB,0xEF,0xFF,0xE3,0x8F,0xFF,0xF9,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x70,0x00,0x00,0x00,0x0F,0xFF,0x70,0x4E,0xFF,0xE2,0x07,0xFF,0xD0,0x00,0x00,0x00,0x0F,0xFF,0x20,0x06,0xFF,0xB0,0x00,0xDF,0xF0,0x00,0x00,0x00,0x0F,0xFE,0x00,0x04,0xFF,0x80,0x00,0xCF,0xF0,0x00,0x00,0x00,0x0F,0xFA,0x00,0x04,0xFF,0x80,0x00,0xCF,0xF0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x04,0xFF,0x80,0x00,0xCF,0xF0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x04,0xFF,0x80,0x00,0xCF,0xF0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x04,0xFF,0x80,0x00,0xCF,0xF0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x04,0xFF,0x80,0x00,0xCF,0xF0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x04,0xFF,0x80,0x00,0xCF,0xF0,0x00,0x00,0x00,0x0F,0xF8,0x00,0x03,0xCC,0x60,0x00,0x9C,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_32_2[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x34,0x00,0x00,0x00,0x00,0x00,0x01,0xB4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0x70,0x00,0x00,0x00,0x00,0x1D,0xFF,0xE6,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFF,0xFB,0x10,0x00,0x00,0x00,0xCF,0xFF,0xFF,0xE7,0x10,0x00,0x00,0x00,0x00,0x0A,0xFF,0xFF,0xD3,0x00,0x00,0x00,0x06,0xEF,0xFF,0xFF,0xF8,0x10,0x00,0x00,0x00,0x00,0xAF,0xFF,0xFF,0x10,0x00,0x00,0x00,0x06,0xEF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0xE3,0x00,0x28,0x74,0x44,0x44,0x4B,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x9D,0x10,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0x95,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x01,0x00,0x00,0x00,0x04,0x00,0x00,0x00,0x00,0x3C,0xCC,0xCC,0xDF,0xFF,0x40,0x00,0x1D,0x10,0x00,0x01,0xAF,0x91,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x40,0x00,0x8F,0xD1,0x00,0x1D,0xFF,0xFE,0x40,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x40,0x02,0xFF,0xFB,0x00,0x06,0xFF,0xFF,0xF9,0x00,0x04,0x88,0x88,0x88,0x8F,0xFF,0x60,0x0B,0xFF,0xFF,0x40,0x00,0x3F,0xFF,0xFF,0x70,0x08,0xFF,0xFF,0xFF,0xCF,0xFF,0xE0,0x6F,0xFF,0xD3,0x00,0x00,0x01,0xDF,0xF6,0x00,0x08,0xFF,0xFF,0xFF,0x8F,0xFF,0xFB,0xFF,0xF9,0x10,0x00,0x00,0x00,0x1C,0x30,0x00,0x04,0x88,0x8F,0xFF,0x7F,0xFF,0xFF,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x2F,0xFF,0x4F,0xFF,0xFF,0xD1,0x00,0x00,0x00,0x00,0x00,0x02,0x10,0x00,0x00,0x00,0x6F,0xFC,0x4F,0xFF,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x09,0xE6,0x10,0x00,0x00,0xBF,0xF7,0x4F,0xFF,0xFF,0xFC,0x00,0x00,0x00,0x00,0x00,0x0D,0xFF,0xE0,0x00,0x02,0xFF,0xF2,0x4F,0xFF,0x9F,0xFF,0x90,0x00,0x00,0x00,0x00,0x2F,0xFF,0x90,0x00,0x0B,0xFF,0xC0,0x4F,0xFF,0x4B,0xFF,0xF6,0x00,0x00,0x00,0x00,0x7F,0xFF,0x30,0x00,0x5F,0xFF,0x60,0x4F,0xFF,0x41,0xFF,0xFF,0x70,0x00,0x00,0x00,0xDF,0xFE,0x00,0x03,0xFF,0xFC,0x00,0x4F,0xFF,0x40,0x4F,0xFF,0xFB,0x10,0x00,0x03,0xFF,0xF8,0x00,0x4F,0xFF,0xF3,0x00,0x4F,0xFF,0x40,0x06,0xFF,0xFF,0xF6,0x00,0x0A,0xFF,0xF2,0x08,0xFF,0xFF,0x80,0x00,0x4F,0xFF,0x40,0x00,0xAF,0xFF,0xF3,0x00,0x4F,0xFF,0xD0,0xBF,0xFF,0xFA,0x00,0x00,0x4F,0xFF,0x40,0x00,0x0A,0xFF,0x80,0x00,0xDF,0xFF,0x70,0x1A,0xFF,0xA0,0x07,0xCC,0xDF,0xFF,0x40,0x00,0x00,0xAE,0x00,0x0A,0xFF,0xFF,0x20,0x00,0xA9,0x00,0x00,0xFF,0xFF,0xFF,0x40,0x00,0x00,0x03,0x00,0x03,0x9F,0xFD,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0x01,0x66,0x00,0x00,0x00,0x00,0x00,0x4F,0xFE,0x81,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x38,0x88,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x10,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0x1F,0xFF,0xFF,0x70,0x00,0x00,0x00,0x00,0x4F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xDF,0xFF,0xFA,0x00,0x00,0x00,0x00,0x4F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1D,0xFF,0xFF,0x30,0xEF,0xFD,0x00,0x4F,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xDF,0xD1,0x00,0xCF,0xFB,0x00,0x4F,0xFF,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x00,0x19,0x00,0x00,0xCF,0xF8,0x00,0x4F,0xFF,0x00,0x03,0x9D,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xCF,0xF8,0x00,0x4F,0xFF,0x39,0xEF,0xFF,0x80,0x00,0x00,0x09,0x40,0x00,0x00,0x00,0xCF,0xF8,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x01,0xCF,0xF9,0x10,0x00,0x00,0xCF,0xF9,0x6A,0xFF,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x09,0xFF,0xFF,0xE4,0x00,0x00,0xCF,0xFF,0xFF,0xFF,0xFF,0xE9,0x3C,0xFF,0x80,0x00,0x00,0x7F,0xFF,0xFF,0x82,0x7C,0xFF,0xFF,0xFF,0xFF,0xFF,0x00,0x0C,0xFF,0x80,0x00,0x00,0x04,0xFF,0xFF,0x7F,0xFF,0xFF,0xFF,0xE9,0x7F,0xFF,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x3F,0xD2,0x0E,0xFF,0xFF,0xF9,0x00,0x4F,0xFF,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x03,0x10,0x09,0xE9,0xDF,0xF8,0x00,0x4F,0xFF,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0xCF,0xF8,0x00,0x4F,0xFF,0x00,0x0C,0xFF,0x80,0x00,0x00,0x00,0x03,0xB2,0x00,0x00,0xCF,0xF8,0x00,0x4F,0xFF,0x00,0x0D,0xFF,0xC0,0x00,0x00,0x00,0x07,0xFF,0xB2,0x00,0xCF,0xF8,0x00,0x4F,0xFF,0x9C,0xEF,0xFF,0xA0,0x00,0x00,0x00,0x0B,0xFF,0xF0,0x00,0xCF,0xF8,0x00,0x4F,0xFF,0x3F,0xFF,0xFF,0x60,0x00,0x00,0x00,0x1F,0xFF,0xA0,0x00,0xCF,0xF8,0x00,0x4F,0xFF,0x1B,0xFF,0xF9,0x00,0x00,0x00,0x00,0x6F,0xFF,0x50,0x00,0xCF,0xF8,0x00,0x4F,0xFF,0x46,0xB7,0x20,0x00,0x00,0x00,0x00,0xCF,0xFF,0x00,0x00,0xCF,0xF8,0x00,0x8F,0xFF,0x40,0x00,0x08,0x10,0x00,0x00,0x02,0xFF,0xFA,0x00,0x00,0xCF,0xF8,0x00,0x8F,0xFF,0x60,0x00,0x0C,0xF9,0x30,0x00,0x0B,0xFF,0xF5,0x00,0x00,0xCF,0xF9,0x00,0x00,0x00,0x00,0x00,0x0E,0xFF,0xF6,0x00,0x4F,0xFF,0xF0,0x00,0x00,0xCF,0xFF,0x54,0x44,0x44,0x44,0x44,0x6F,0xFF,0xF2,0x02,0xFF,0xFF,0x90,0x00,0x00,0x9F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x05,0xBF,0xFF,0x30,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x40,0x00,0x02,0x8D,0x00,0x00,0x00,0x09,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x30,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x03,0x8C,0x80,0x00,0x00,0x00,0xFE,0x93,0x00,0x00,0x00,0x00,0x1D,0xFB,0x10,0x00,0x06,0xFF,0xE0,0x00,0x00,0x05,0xFF,0xF5,0x00,0x00,0x00,0x00,0xEF,0xFF,0xD1,0x00,0x01,0xFF,0xF5,0x00,0x00,0x09,0xFF,0xC0,0x00,0x00,0x00,0x00,0x2D,0xFF,0xFF,0x30,0x00,0xAF,0xFA,0x00,0x00,0x0E,0xFF,0x50,0x00,0x14,0x20,0x00,0x01,0xDF,0xFF,0xE1,0x00,0x6B,0x83,0x00,0x00,0x5F,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x2F,0xFD,0xFD,0xCC,0xCC,0xCC,0xEF,0x40,0xCF,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x03,0xA1,0xFF,0xFF,0xFF,0xFF,0xFF,0x44,0xFF,0xFC,0xCC,0xCC,0xCC,0x60,0x00,0x00,0x00,0x00,0xFF,0xFF,0xFF,0xFF,0xFF,0x4D,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x31,0x00,0x00,0x42,0xCF,0xF4,0x00,0x24,0x9F,0xFE,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0x40,0x00,0x00,0xCF,0xF4,0x00,0x06,0xFF,0xFE,0xCC,0xCC,0xCC,0xCC,0x60,0x4F,0xFF,0xF8,0x00,0x00,0xCF,0xF4,0x00,0x3F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x80,0x08,0xFF,0xFF,0xC1,0x00,0xCF,0xFF,0xFF,0xFF,0xDF,0xAC,0xCC,0xCD,0xFF,0xFF,0x80,0x00,0x6F,0xFF,0xF7,0x00,0xCF,0xFF,0xFF,0xFF,0x53,0x00,0x00,0x0C,0xFF,0xF4,0x00,0x00,0x06,0xFF,0x60,0x00,0xCF,0xFC,0xCF,0xFF,0x40,0x00,0x00,0xAF,0xFF,0x30,0x00,0x00,0x00,0x63,0x00,0x00,0xFF,0xF0,0x0C,0xFF,0x40,0x00,0x0B,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0xF0,0x0C,0xFF,0x00,0x00,0x0F,0xFF,0x80,0x00,0x00,0x00,0x00,0x13,0x00,0x02,0xFF,0xD0,0x0C,0xFF,0x4F,0xCC,0xCF,0xFF,0xDC,0xCF,0xC0,0x00,0x00,0x5F,0xA4,0x04,0xFF,0xC0,0x0F,0xFF,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x9F,0xFE,0x08,0xFF,0x90,0x0F,0xFD,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0xDF,0xF9,0x0B,0xFF,0x60,0x0F,0xFC,0x14,0x44,0x4D,0xFF,0x74,0x44,0x30,0x00,0x02,0xFF,0xF4,0x0F,0xFF,0x30,0x1F,0xFC,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x00,0x07,0xFF,0xF0,0x5F,0xFF,0x00,0x4F,0xF9,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x00,0x0E,0xFF,0xA0,0xAF,0xFA,0x00,0x4F,0xF8,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x00,0x4F,0xFF,0x52,0xFF,0xF5,0x00,0x6F,0xF7,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x00,0xCF,0xFF,0x1A,0xFF,0xE6,0x44,0xCF,0xF4,0x00,0x00,0x0C,0xFF,0x40,0x00,0x00,0x05,0xFF,0xFB,0x5F,0xFF,0x61,0xFF,0xFF,0xF3,0x04,0x96,0x6F,0xFF,0x40,0x00,0x00,0x3F,0xFF,0xF7,0xFF,0xFE,0x00,0x9F,0xFF,0xF0,0x00,0xAF,0xFF,0xFF,0x40,0x00,0x00,0x03,0xAF,0xF2,0x3E,0xF4,0x00,0x4F,0xFE,0x30,0x00,0x3F,0xFF,0xFE,0x00,0x00,0x00,0x00,0x01,0x60,0x01,0x80,0x00,0x26,0x30,0x00,0x00,0x0F,0xFF,0xC3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x53,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x34,0x00,0x00,0x00,0x00,0x00,0x01,0xB4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0x70,0x00,0x00,0x00,0x00,0x1D,0xFF,0xE6,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFF,0xFB,0x10,0x00,0x00,0x00,0xCF,0xFF,0xFF,0xE7,0x10,0x00,0x00,0x00,0x00,0x0A,0xFF,0xFF,0xD3,0x00,0x00,0x00,0x06,0xEF,0xFF,0xFF,0xF8,0x10,0x00,0x00,0x00,0x00,0xAF,0xFF,0xFF,0x10,0x00,0x00,0x00,0x06,0xEF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0xE3,0x00,0x28,0x74,0x44,0x44,0x4B,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x9D,0x10,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0x95,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x01,0x00,0x00,0x00,0x04,0x00,0x00,0x00,0x00,0x3C,0xCC,0xCC,0xDF,0xFF,0x40,0x00,0x1D,0x10,0x00,0x01,0xAF,0x91,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x40,0x00,0x8F,0xD1,0x00,0x1D,0xFF,0xFE,0x40,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x40,0x02,0xFF,0xFB,0x00,0x06,0xFF,0xFF,0xF9,0x00,0x04,0x88,0x88,0x88,0x8F,0xFF,0x60,0x0B,0xFF,0xFF,0x40,0x00,0x3F,0xFF,0xFF,0x70,0x08,0xFF,0xFF,0xFF,0xCF,0xFF,0xE0,0x6F,0xFF,0xD3,0x00,0x00,0x01,0xDF,0xF6,0x00,0x08,0xFF,0xFF,0xFF,0x8F,0xFF,0xFB,0xFF,0xF9,0x10,0x00,0x00,0x00,0x1C,0x30,0x00,0x04,0x88,0x8F,0xFF,0x7F,0xFF,0xFF,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x2F,0xFF,0x4F,0xFF,0xFF,0xD1,0x00,0x00,0x00,0x00,0x00,0x02,0x10,0x00,0x00,0x00,0x6F,0xFC,0x4F,0xFF,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x09,0xE6,0x10,0x00,0x00,0xBF,0xF7,0x4F,0xFF,0xFF,0xFC,0x00,0x00,0x00,0x00,0x00,0x0D,0xFF,0xE0,0x00,0x02,0xFF,0xF2,0x4F,0xFF,0x9F,0xFF,0x90,0x00,0x00,0x00,0x00,0x2F,0xFF,0x90,0x00,0x0B,0xFF,0xC0,0x4F,0xFF,0x4B,0xFF,0xF6,0x00,0x00,0x00,0x00,0x7F,0xFF,0x30,0x00,0x5F,0xFF,0x60,0x4F,0xFF,0x41,0xFF,0xFF,0x70,0x00,0x00,0x00,0xDF,0xFE,0x00,0x03,0xFF,0xFC,0x00,0x4F,0xFF,0x40,0x4F,0xFF,0xFB,0x10,0x00,0x03,0xFF,0xF8,0x00,0x4F,0xFF,0xF3,0x00,0x4F,0xFF,0x40,0x06,0xFF,0xFF,0xF6,0x00,0x0A,0xFF,0xF2,0x08,0xFF,0xFF,0x80,0x00,0x4F,0xFF,0x40,0x00,0xAF,0xFF,0xF3,0x00,0x4F,0xFF,0xD0,0xBF,0xFF,0xFA,0x00,0x00,0x4F,0xFF,0x40,0x00,0x0A,0xFF,0x80,0x00,0xDF,0xFF,0x70,0x1A,0xFF,0xA0,0x07,0xCC,0xDF,0xFF,0x40,0x00,0x00,0xAE,0x00,0x0A,0xFF,0xFF,0x20,0x00,0xA9,0x00,0x00,0xFF,0xFF,0xFF,0x40,0x00,0x00,0x03,0x00,0x03,0x9F,0xFD,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0x01,0x66,0x00,0x00,0x00,0x00,0x00,0x4F,0xFE,0x81,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x20,0x00,0x00,0x00,0x00,0x00,0x00,
							0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xCC,0xCC,0xCC,0xCC,0xFF,0xFF,0xE1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1E,0xFF,0xF5,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xBF,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFE,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xEF,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x05,0xFF,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0B,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1F,0xFF,0xF1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x5F,0xFF,0xA0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xDF,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x44,0x42,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x24,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x8F,0xFF,0xFF,0xB4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xFF,0xFF,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xEF,0xFF,0xFC,0xEF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xFC,0x10,0x07,0xFF,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xFF,0xF1,0x00,0x00,0xCF,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x2F,0xFF,0xC0,0x00,0x00,0x8F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x25,0x40,0x00,0x00,0xBF,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x47,0xAF,0xFF,0xF5,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xFF,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x86,0x7B,0xFF,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7F,0xFF,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x10,0x00,0x00,0x0C,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFF,0x70,0x00,0x00,0x0C,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xB0,0x00,0x00,0x0F,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xF4,0x00,0x00,0xAF,0xFF,0xB0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xFF,0x97,0x8D,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xDF,0xFF,0xFF,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1A,0xFF,0xFF,0xFF,0xFC,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x27,0x88,0x86,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x44,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x48,0xC9,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xDC,0xFF,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xC5,0x5A,0xFF,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFA,0x00,0x00,0x6F,0xFF,0xB0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xE0,0x00,0x00,0x0D,0xFF,0xF1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x08,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x04,0xFF,0xF5,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x04,0xFF,0xF7,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x05,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x08,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xF0,0x00,0x00,0x0E,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xF7,0x00,0x00,0x7F,0xFF,0xA0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0x84,0x49,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xFF,0xEE,0xFF,0xFF,0xFE,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0x88,0x61,0x6A,0xC8,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x88,0x60,0x48,0xC8,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xDC,0xFF,0xFF,0xFE,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xE8,0x8C,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFB,0x00,0x00,0xAF,0xFF,0xA0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF1,0x00,0x00,0x1F,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0x0A,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0x08,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0x08,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0x08,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0x0B,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF1,0x00,0x00,0x1F,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF8,0x00,0x00,0xAF,0xFF,0xA0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xA5,0x5C,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xEE,0xFF,0xFF,0xFE,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC1,0x6A,0xB8,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x09,0xCC,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x88,0x61,0x7C,0xFE,0xA2,0x00,0x17,0xCC,0xC7,0x10,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xDD,0xFF,0xFF,0xFF,0x63,0xFF,0xFF,0xFF,0xE3,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFD,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0x74,0x9F,0xFF,0xFF,0xF6,0x5A,0xFF,0xFF,0x50,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFC,0x00,0x04,0xFF,0xFF,0x80,0x00,0x7F,0xFF,0x80,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF9,0x00,0x00,0xDF,0xFF,0x30,0x00,0x1F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF4,0x00,0x00,0xCF,0xFF,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF0,0x00,0x00,0xCF,0xFF,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0xCF,0xFF,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0xCF,0xFF,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0xCF,0xFF,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0xCF,0xFF,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0xCF,0xFF,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0xCF,0xFF,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0xCF,0xFF,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x0C,0xFF,0xC0,0x00,0x00,0xCF,0xFF,0x00,0x00,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x00,0x06,0x88,0x60,0x00,0x00,0x34,0x44,0x00,0x00,0x04,0x44,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};

const uint8_t t_16_2_5[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xB3,0x00,0x00,0x3E,0x60,0x00,0x00,0x0A,0xFF,0x60,0x00,0x9F,0xFE,0x71,0x00,0x00,0xAF,0xD1,0x34,0x46,0xEF,0x60,0x00,0x00,0x07,0x00,0xCF,0xFF,0xF6,0x01,0x00,0x09,0x40,0x00,0x68,0x8E,0xF4,0x0B,0x30,0x7F,0xF8,0x01,0x44,0x4D,0xF4,0x4F,0xF3,0x06,0xFD,0x34,0xFF,0xFF,0xFB,0xEF,0x60,0x00,0x51,0x01,0x4B,0xFD,0xFF,0xD2,0x00,0x00,0x46,0x00,0x0E,0xEC,0xFF,0xD0,0x00,0x00,0x9F,0x70,0x4F,0x9C,0xFD,0xFA,0x00,0x00,0xEF,0x21,0xEF,0x2C,0xF5,0xDF,0xA1,0x04,0xFB,0x3D,0xF8,0x0C,0xF4,0x3F,0xFB,0x0D,0xF6,0xAF,0xA3,0x8E,0xF4,0x03,0xF2,0x5E,0xF1,0x04,0x00,0xEF,0xF3,0x00,0x10,0x00,0x40,0x00,0x00,0x79,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x41,0x00,0x00,0x01,0xC6,0x00,0x00,0x0C,0xF3,0x00,0x00,0x06,0xFF,0xA0,0x00,0x0C,0xF0,0x00,0x00,0x00,0x6F,0xB1,0xFF,0x0C,0xF0,0x00,0x10,0x00,0x04,0x00,0xFC,0x0C,0xF5,0xAE,0x40,0x0A,0x91,0x00,0xFC,0x5E,0xFF,0xFF,0x40,0x3F,0xFD,0x46,0xFF,0xFF,0xF6,0x9F,0x40,0x02,0xDC,0xAF,0xFF,0x7D,0xF0,0x8F,0x40,0x00,0x10,0x37,0xFC,0x0C,0xF0,0x8F,0x50,0x00,0x4B,0x40,0xFC,0x0C,0xF7,0xCF,0x80,0x00,0x8F,0x70,0xFC,0x0C,0xF9,0xFF,0x20,0x00,0xEF,0x20,0xFC,0x0C,0xF6,0x54,0x00,0x04,0xFD,0x00,0xFD,0x06,0x82,0x08,0xE7,0x1E,0xF7,0x00,0xFF,0xBC,0xCC,0xCE,0xF9,0x27,0xE2,0x00,0x9F,0xFF,0xFF,0xFF,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x04,0xA0,0x04,0xD6,0x00,0x2F,0xA0,0x00,0x0D,0xFD,0x10,0xFD,0x00,0x7F,0x60,0x21,0x01,0xDF,0xD8,0xDC,0x80,0xEF,0xFF,0xF4,0x00,0x13,0xFF,0xFF,0xF5,0xFA,0x88,0x82,0x1A,0x10,0x3F,0x80,0x5F,0xF5,0x44,0x41,0x8F,0xF4,0x0F,0xC8,0xDF,0xFF,0xFF,0xF4,0x08,0xF8,0x0F,0xEE,0xF5,0x00,0xAF,0x60,0x00,0x30,0x0F,0x88,0xF2,0x07,0xF8,0x00,0x00,0x83,0x3F,0x88,0xFC,0xFF,0xFF,0xF4,0x00,0xFF,0x6F,0x48,0xF9,0xAC,0xFA,0xC3,0x03,0xFA,0xAF,0x1A,0xE0,0x08,0xF4,0x00,0x0A,0xF6,0xFD,0x0C,0xC0,0x08,0xF4,0x00,0x2F,0xF9,0xF9,0xCF,0xC1,0x5A,0xF4,0x00,0x6E,0xCD,0xD0,0xCF,0x50,0xCF,0xF2,0x00,0x00,0x20,0x30,0x21,0x00,0x6C,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xB3,0x00,0x00,0x3E,0x60,0x00,0x00,0x0A,0xFF,0x60,0x00,0x9F,0xFE,0x71,0x00,0x00,0xAF,0xD1,0x34,0x46,0xEF,0x60,0x00,0x00,0x07,0x00,0xCF,0xFF,0xF6,0x01,0x00,0x09,0x40,0x00,0x68,0x8E,0xF4,0x0B,0x30,0x7F,0xF8,0x01,0x44,0x4D,0xF4,0x4F,0xF3,0x06,0xFD,0x34,0xFF,0xFF,0xFB,0xEF,0x60,0x00,0x51,0x01,0x4B,0xFD,0xFF,0xD2,0x00,0x00,0x46,0x00,0x0E,0xEC,0xFF,0xD0,0x00,0x00,0x9F,0x70,0x4F,0x9C,0xFD,0xFA,0x00,0x00,0xEF,0x21,0xEF,0x2C,0xF5,0xDF,0xA1,0x04,0xFB,0x3D,0xF8,0x0C,0xF4,0x3F,0xFB,0x0D,0xF6,0xAF,0xA3,0x8E,0xF4,0x03,0xF2,0x5E,0xF1,0x04,0x00,0xEF,0xF3,0x00,0x10,0x00,0x40,0x00,0x00,0x79,0x40,0x00,0x00};
const uint8_t t_24_2_5[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x00,0x03,0x20,0x00,0x00,0x00,0x00,0x00,0x3F,0xC1,0x00,0x00,0x00,0x3F,0xFA,0x40,0x00,0x00,0x00,0x03,0xFF,0xFF,0x30,0x00,0x01,0xDF,0xFF,0xFC,0x40,0x00,0x00,0x00,0x5F,0xFF,0xF6,0x00,0x00,0x06,0xEF,0xFF,0xF6,0x00,0x00,0x00,0x03,0xFF,0xD3,0x04,0x86,0x44,0x4A,0xFF,0x60,0x00,0x00,0x00,0x00,0x3B,0x10,0x08,0xFF,0xFF,0xFF,0xF5,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x08,0xFF,0xFF,0xFF,0xF0,0x00,0x60,0x00,0x04,0xF8,0x00,0x00,0x02,0x43,0x00,0xFF,0xC0,0x02,0xFA,0x00,0x4F,0xFF,0xD3,0x00,0x00,0x00,0x00,0xFF,0xC0,0x0B,0xFF,0x60,0x08,0xFF,0xFF,0x60,0x4F,0xFF,0xFF,0xFF,0xF2,0x6F,0xFF,0x90,0x00,0x5F,0xFA,0x00,0x4F,0xFF,0xFD,0xFF,0xFC,0xFF,0xE4,0x00,0x00,0x03,0x60,0x00,0x28,0x8E,0xFC,0xFF,0xFF,0xF9,0x10,0x00,0x00,0x00,0x10,0x00,0x00,0x0F,0xF8,0xFF,0xFF,0xC0,0x00,0x00,0x00,0x00,0xE6,0x10,0x00,0x6F,0xF4,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x04,0xFF,0xC0,0x00,0xCF,0xE0,0xFF,0xDF,0xFF,0x30,0x00,0x00,0x09,0xFF,0x60,0x05,0xFF,0x80,0xFF,0xC5,0xFF,0xF3,0x00,0x00,0x0E,0xFF,0x10,0x3F,0xFF,0x10,0xFF,0xC0,0xAF,0xFF,0x70,0x00,0x5F,0xFB,0x04,0xFF,0xF7,0x00,0xFF,0xC0,0x1D,0xFF,0xFB,0x00,0xCF,0xF7,0xAF,0xFF,0xB0,0x00,0xFF,0xC0,0x01,0xDF,0xF3,0x07,0xFF,0xF1,0x3F,0xFD,0x14,0xC9,0xFF,0xC0,0x00,0x1D,0x80,0x3F,0xFF,0xB0,0x01,0x81,0x00,0xEF,0xFF,0xC0,0x00,0x01,0x20,0x01,0x7E,0x60,0x00,0x00,0x00,0x9F,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x38,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x30,0x00,0x00,0x00,0x02,0xFF,0xC0,0x00,0x00,0x00,0x00,0x3F,0xF6,0x00,0x00,0x00,0x00,0xFF,0xC0,0x00,0x00,0x00,0x00,0xDF,0xFF,0xA0,0x00,0x00,0x00,0xFF,0xC0,0x00,0x00,0x00,0x00,0x1B,0xFF,0xFB,0x08,0x88,0x00,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0xAF,0xC1,0x0F,0xFE,0x00,0xFF,0xC0,0x00,0x02,0x00,0x00,0x00,0x08,0x00,0x0F,0xFC,0x00,0xFF,0xC0,0x5A,0xF8,0x00,0x00,0x31,0x00,0x00,0x0F,0xFC,0x00,0xFF,0xFF,0xFF,0xF8,0x00,0x05,0xFF,0x50,0x00,0x0F,0xFD,0x6B,0xFF,0xFF,0xFF,0xF8,0x00,0x1E,0xFF,0xFA,0x10,0x2F,0xFF,0xFF,0xFF,0xF9,0x7F,0xF8,0x00,0x01,0xCF,0xFF,0xDD,0xFF,0xFF,0xFE,0xFF,0xC0,0x4F,0xF8,0x00,0x00,0x0A,0xF6,0x3F,0xFF,0xFE,0x30,0xFF,0xC0,0x4F,0xF8,0x00,0x00,0x00,0x40,0x0E,0x9F,0xFC,0x00,0xFF,0xC0,0x4F,0xF8,0x00,0x00,0x00,0x50,0x00,0x0F,0xFC,0x00,0xFF,0xC0,0x3F,0xF8,0x00,0x00,0x00,0xEE,0x80,0x0F,0xFC,0x00,0xFF,0xFC,0xDF,0xF8,0x00,0x00,0x03,0xFF,0xD0,0x0F,0xFC,0x00,0xFF,0xCE,0xFF,0xF5,0x00,0x00,0x07,0xFF,0x70,0x0F,0xFC,0x00,0xFF,0xC7,0xFE,0x50,0x00,0x00,0x0E,0xFF,0x20,0x0F,0xFC,0x04,0xFF,0xC1,0x00,0x61,0x00,0x00,0x4F,0xFD,0x00,0x0F,0xFC,0x04,0xFF,0xF0,0x00,0xCF,0x93,0x00,0xDF,0xF7,0x00,0x0F,0xFE,0x10,0x00,0x00,0x00,0xEF,0xF9,0x0A,0xFF,0xF2,0x00,0x0D,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF4,0x16,0xDF,0xD0,0x00,0x08,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x04,0x50,0x00,0x00,0x8C,0xCC,0xCC,0xCC,0xCC,0xC9,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x02,0x50,0x00,0x00,0x77,0x20,0x00,0x00,0x00,0xAF,0x60,0x00,0x7F,0xF3,0x00,0x00,0xDF,0xF3,0x00,0x00,0x07,0xFF,0xF8,0x00,0x1F,0xFA,0x00,0x02,0xFF,0xA0,0x00,0x00,0x00,0xAF,0xFF,0xA0,0x0C,0xFB,0x00,0x07,0xFF,0xDC,0xCC,0x90,0x00,0x0A,0xFF,0xEC,0xCE,0xCC,0xCA,0x0E,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x81,0xFF,0xFF,0xFF,0xFC,0x6F,0xF9,0x88,0x8A,0x90,0x00,0x10,0x00,0xCE,0xFF,0xCC,0xCA,0xFF,0xC0,0x00,0x00,0x00,0x09,0xE4,0x00,0x08,0xFF,0x00,0x0C,0xFF,0xB8,0x88,0x88,0x80,0x7F,0xFF,0x70,0x08,0xFF,0x88,0xBF,0xFF,0xFF,0xFF,0xFF,0xF0,0x0A,0xFF,0xFA,0x08,0xFF,0xFF,0xFF,0xA8,0x74,0x5F,0xFF,0x90,0x00,0x7F,0xD2,0x08,0xFF,0xCE,0xFC,0x00,0x01,0xDF,0xF3,0x00,0x00,0x05,0x10,0x08,0xFD,0x09,0xFC,0x00,0x0C,0xFF,0x70,0x00,0x00,0x01,0x00,0x0B,0xFC,0x0C,0xFA,0x98,0x8E,0xFF,0x88,0x81,0x00,0x09,0xA4,0x0C,0xFB,0x0C,0xF8,0xFF,0xFF,0xFF,0xFF,0xF0,0x00,0x0D,0xFF,0x1F,0xF8,0x0C,0xF8,0xFF,0xFF,0xFF,0xFF,0xF0,0x00,0x1F,0xFB,0x4F,0xF5,0x0E,0xF7,0x00,0x0C,0xFC,0x00,0x00,0x00,0x6F,0xF6,0x9F,0xF1,0x0F,0xF4,0x00,0x0C,0xFC,0x00,0x00,0x00,0xCF,0xF1,0xEF,0xD0,0x0F,0xF4,0x00,0x0C,0xFC,0x00,0x00,0x04,0xFF,0xC6,0xFF,0x90,0x4F,0xF1,0x00,0x0C,0xFC,0x00,0x00,0x0D,0xFF,0x8F,0xFF,0x4F,0xFF,0xF0,0x38,0x4E,0xFC,0x00,0x00,0x6F,0xFF,0xAF,0xF8,0x0A,0xFF,0xC0,0x0C,0xFF,0xFC,0x00,0x00,0x01,0x8C,0x06,0xD0,0x08,0xD9,0x10,0x05,0xFF,0xF5,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x01,0xC8,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x00,0x03,0x20,0x00,0x00,0x00,0x00,0x00,0x3F,0xC1,0x00,0x00,0x00,0x3F,0xFA,0x40,0x00,0x00,0x00,0x03,0xFF,0xFF,0x30,0x00,0x01,0xDF,0xFF,0xFC,0x40,0x00,0x00,0x00,0x5F,0xFF,0xF6,0x00,0x00,0x06,0xEF,0xFF,0xF6,0x00,0x00,0x00,0x03,0xFF,0xD3,0x04,0x86,0x44,0x4A,0xFF,0x60,0x00,0x00,0x00,0x00,0x3B,0x10,0x08,0xFF,0xFF,0xFF,0xF5,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x08,0xFF,0xFF,0xFF,0xF0,0x00,0x60,0x00,0x04,0xF8,0x00,0x00,0x02,0x43,0x00,0xFF,0xC0,0x02,0xFA,0x00,0x4F,0xFF,0xD3,0x00,0x00,0x00,0x00,0xFF,0xC0,0x0B,0xFF,0x60,0x08,0xFF,0xFF,0x60,0x4F,0xFF,0xFF,0xFF,0xF2,0x6F,0xFF,0x90,0x00,0x5F,0xFA,0x00,0x4F,0xFF,0xFD,0xFF,0xFC,0xFF,0xE4,0x00,0x00,0x03,0x60,0x00,0x28,0x8E,0xFC,0xFF,0xFF,0xF9,0x10,0x00,0x00,0x00,0x10,0x00,0x00,0x0F,0xF8,0xFF,0xFF,0xC0,0x00,0x00,0x00,0x00,0xE6,0x10,0x00,0x6F,0xF4,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x04,0xFF,0xC0,0x00,0xCF,0xE0,0xFF,0xDF,0xFF,0x30,0x00,0x00,0x09,0xFF,0x60,0x05,0xFF,0x80,0xFF,0xC5,0xFF,0xF3,0x00,0x00,0x0E,0xFF,0x10,0x3F,0xFF,0x10,0xFF,0xC0,0xAF,0xFF,0x70,0x00,0x5F,0xFB,0x04,0xFF,0xF7,0x00,0xFF,0xC0,0x1D,0xFF,0xFB,0x00,0xCF,0xF7,0xAF,0xFF,0xB0,0x00,0xFF,0xC0,0x01,0xDF,0xF3,0x07,0xFF,0xF1,0x3F,0xFD,0x14,0xC9,0xFF,0xC0,0x00,0x1D,0x80,0x3F,0xFF,0xB0,0x01,0x81,0x00,0xEF,0xFF,0xC0,0x00,0x01,0x20,0x01,0x7E,0x60,0x00,0x00,0x00,0x9F,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x38,0x50,0x00,0x00,0x00,0x00};
const uint8_t t_32_2_5[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x66,0x00,0x00,0x00,0x00,0x00,0x02,0xD7,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0xA1,0x00,0x00,0x00,0x00,0x1D,0xFF,0xF8,0x10,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xFD,0x20,0x00,0x00,0x01,0xDF,0xFF,0xFF,0xFA,0x20,0x00,0x00,0x00,0x00,0x1D,0xFF,0xFF,0xF5,0x00,0x00,0x00,0x28,0xFF,0xFF,0xFF,0xFA,0x10,0x00,0x00,0x00,0x01,0xCF,0xFF,0xFF,0x30,0x00,0x00,0x00,0x18,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x0A,0xFF,0xE3,0x00,0x28,0x88,0x88,0x88,0x9F,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0xCD,0x10,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xB7,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x11,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x02,0x00,0x00,0x00,0x05,0x00,0x00,0x00,0x00,0x4F,0xFC,0xCC,0xDF,0xFF,0x80,0x00,0x2F,0x10,0x00,0x01,0xCF,0xC2,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x80,0x00,0xAF,0xD1,0x00,0x3D,0xFF,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x80,0x03,0xFF,0xFD,0x10,0x0A,0xFF,0xFF,0xFC,0x10,0x06,0xCC,0xCC,0xCC,0xBF,0xFF,0x90,0x0C,0xFF,0xFF,0x80,0x00,0x6F,0xFF,0xFF,0x90,0x08,0xFF,0xFF,0xFF,0xCF,0xFF,0xF1,0x8F,0xFF,0xF7,0x00,0x00,0x03,0xFF,0xF6,0x00,0x08,0xFF,0xFF,0xFF,0xCF,0xFF,0xFC,0xFF,0xFD,0x20,0x00,0x00,0x00,0x3E,0x30,0x00,0x04,0x88,0x8F,0xFF,0x8F,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x6F,0xFF,0xFF,0xE2,0x00,0x00,0x00,0x00,0x00,0x03,0x10,0x00,0x00,0x00,0x8F,0xFE,0x4F,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x0B,0xE6,0x10,0x00,0x00,0xEF,0xFA,0x4F,0xFF,0xFF,0xFE,0x10,0x00,0x00,0x00,0x00,0x0F,0xFF,0xF1,0x00,0x04,0xFF,0xF5,0x4F,0xFF,0xFF,0xFF,0xB0,0x00,0x00,0x00,0x00,0x4F,0xFF,0xB0,0x00,0x0D,0xFF,0xE0,0x4F,0xFF,0x8D,0xFF,0xFA,0x00,0x00,0x00,0x00,0x9F,0xFF,0x60,0x00,0x8F,0xFF,0x80,0x4F,0xFF,0x83,0xFF,0xFF,0xA1,0x00,0x00,0x00,0xFF,0xFF,0x10,0x06,0xFF,0xFF,0x10,0x4F,0xFF,0x80,0x6F,0xFF,0xFD,0x40,0x00,0x06,0xFF,0xFA,0x00,0x7F,0xFF,0xF5,0x00,0x4F,0xFF,0x80,0x0A,0xFF,0xFF,0xFA,0x00,0x0C,0xFF,0xF5,0x2B,0xFF,0xFF,0xB0,0x00,0x4F,0xFF,0x80,0x00,0xBF,0xFF,0xF6,0x00,0x6F,0xFF,0xF1,0xDF,0xFF,0xFD,0x10,0x00,0x4F,0xFF,0x80,0x00,0x1D,0xFF,0x80,0x01,0xFF,0xFF,0xA0,0x0A,0xFF,0xD1,0x08,0xFC,0xEF,0xFF,0x80,0x00,0x01,0xBF,0x10,0x1D,0xFF,0xFF,0x50,0x00,0x7C,0x10,0x00,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x04,0x00,0x03,0xAF,0xFF,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x01,0x69,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xB3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0x41,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x48,0x88,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x6E,0x30,0x00,0x00,0x00,0x00,0x00,0x8F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x7F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xFF,0xA1,0x00,0x00,0x00,0x00,0x4F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xFF,0xFD,0x10,0x00,0x00,0x00,0x4F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xFF,0xFF,0x40,0xFF,0xFF,0x00,0x4F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0xD1,0x00,0xFF,0xFD,0x00,0x4F,0xFF,0x40,0x00,0x00,0x30,0x00,0x00,0x00,0x00,0x3A,0x00,0x00,0xDF,0xFC,0x00,0x4F,0xFF,0x40,0x16,0xAF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xCF,0xFC,0x00,0x4F,0xFF,0x9B,0xFF,0xFF,0xC0,0x00,0x00,0x1D,0x70,0x00,0x00,0x00,0xCF,0xFC,0x00,0x5F,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x01,0xDF,0xFC,0x20,0x00,0x00,0xCF,0xFD,0x7D,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x0C,0xFF,0xFF,0xF7,0x00,0x00,0xCF,0xFF,0xFF,0xFF,0xFF,0xFA,0x5F,0xFF,0xC0,0x00,0x01,0xAF,0xFF,0xFF,0xB5,0x9E,0xFF,0xFF,0xFF,0xFF,0xFF,0x40,0x0F,0xFF,0xC0,0x00,0x00,0x07,0xFF,0xFF,0x8F,0xFF,0xFF,0xFF,0xFB,0x9F,0xFF,0x40,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x6F,0xD2,0x0F,0xFF,0xFF,0xFD,0x10,0x4F,0xFF,0x40,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x05,0x10,0x0A,0xFB,0xEF,0xFC,0x00,0x4F,0xFF,0x40,0x0C,0xFF,0xC0,0x00,0x00,0x00,0x00,0x00,0x03,0x10,0xCF,0xFC,0x00,0x4F,0xFF,0x40,0x0C,0xFF,0xC0,0x00,0x00,0x00,0x05,0xB2,0x00,0x00,0xCF,0xFC,0x00,0x4F,0xFF,0x40,0x1E,0xFF,0xC0,0x00,0x00,0x00,0x09,0xFF,0xB3,0x00,0xCF,0xFC,0x00,0x4F,0xFF,0xFE,0xFF,0xFF,0xC0,0x00,0x00,0x00,0x0E,0xFF,0xF2,0x00,0xCF,0xFC,0x00,0x4F,0xFF,0x8F,0xFF,0xFF,0x80,0x00,0x00,0x00,0x2F,0xFF,0xD0,0x00,0xCF,0xFC,0x00,0x7F,0xFF,0x4C,0xFF,0xFC,0x10,0x00,0x00,0x00,0x8F,0xFF,0x70,0x00,0xCF,0xFC,0x00,0x8F,0xFF,0x47,0xCA,0x50,0x00,0x00,0x00,0x00,0xEF,0xFF,0x20,0x00,0xCF,0xFC,0x00,0x8F,0xFF,0x80,0x00,0x08,0x20,0x00,0x00,0x05,0xFF,0xFD,0x00,0x00,0xCF,0xFC,0x00,0xCF,0xFF,0x80,0x00,0x0F,0xFA,0x30,0x00,0x0D,0xFF,0xF7,0x00,0x00,0xCF,0xFC,0x00,0x34,0x44,0x20,0x00,0x0F,0xFF,0xF9,0x00,0x7F,0xFF,0xF2,0x00,0x00,0xCF,0xFF,0x84,0x44,0x44,0x44,0x44,0x8F,0xFF,0xF5,0x03,0xFF,0xFF,0xC0,0x00,0x00,0xCF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF0,0x06,0xCF,0xFF,0x70,0x00,0x00,0x6F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x02,0x9F,0x20,0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFA,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x34,0x44,0x44,0x44,0x44,0x44,0x44,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x00,0x00,0x00,0x00,0x01,0x91,0x00,0x00,0x03,0x8C,0xA0,0x00,0x00,0x03,0xFE,0xA5,0x00,0x00,0x00,0x00,0x3D,0xFD,0x20,0x00,0x09,0xFF,0xF1,0x00,0x00,0x07,0xFF,0xF7,0x00,0x00,0x00,0x01,0xEF,0xFF,0xF3,0x00,0x02,0xFF,0xF7,0x00,0x00,0x0B,0xFF,0xE0,0x00,0x00,0x00,0x00,0x3F,0xFF,0xFF,0x60,0x00,0xDF,0xFC,0x00,0x00,0x1F,0xFF,0xA4,0x44,0x44,0x20,0x00,0x03,0xFF,0xFF,0xF1,0x00,0x8D,0x84,0x02,0x10,0x7F,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x3F,0xFD,0xFF,0xFF,0xFF,0xFF,0xFF,0x40,0xEF,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x06,0xA1,0xFF,0xFF,0xFF,0xFF,0xFF,0x46,0xFF,0xFC,0xCC,0xCC,0xCF,0x80,0x00,0x00,0x00,0x00,0xFF,0xFF,0xFF,0xFF,0xFF,0x5F,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x33,0x00,0x00,0x44,0xDF,0xF7,0x44,0x44,0xBF,0xFF,0x10,0x00,0x00,0x00,0x00,0x04,0xFF,0x70,0x00,0x00,0xCF,0xF4,0x00,0x07,0xFF,0xFF,0xCC,0xCC,0xCC,0xCC,0x90,0x6F,0xFF,0xFB,0x10,0x00,0xCF,0xF7,0x44,0x8F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x1A,0xFF,0xFF,0xE3,0x00,0xCF,0xFF,0xFF,0xFF,0xDF,0xEF,0xCC,0xCD,0xFF,0xFF,0xC0,0x00,0xAF,0xFF,0xF9,0x00,0xFF,0xFF,0xFF,0xFF,0x83,0x00,0x00,0x1D,0xFF,0xF6,0x00,0x00,0x06,0xFF,0x60,0x00,0xFF,0xFD,0xCF,0xFF,0x60,0x00,0x01,0xDF,0xFF,0x30,0x00,0x00,0x00,0x83,0x00,0x00,0xFF,0xF4,0x0C,0xFF,0x40,0x00,0x2E,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xF0,0x0D,0xFF,0x50,0x00,0x0F,0xFF,0xB0,0x00,0x20,0x00,0x00,0x23,0x00,0x04,0xFF,0xF0,0x0F,0xFF,0x6F,0xFC,0xCF,0xFF,0xEC,0xFF,0xC0,0x00,0x00,0x7F,0xA4,0x07,0xFF,0xD0,0x0F,0xFF,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0xBF,0xFF,0x1A,0xFF,0xC0,0x0F,0xFF,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0xFF,0xFB,0x0D,0xFF,0x80,0x2F,0xFF,0x25,0x44,0x4F,0xFF,0xA4,0x44,0x60,0x00,0x04,0xFF,0xF6,0x2F,0xFF,0x50,0x4F,0xFC,0x00,0x00,0x0F,0xFF,0x80,0x00,0x00,0x00,0x0A,0xFF,0xF2,0x7F,0xFF,0x10,0x4F,0xFC,0x00,0x00,0x0F,0xFF,0x80,0x00,0x00,0x00,0x0F,0xFF,0xD0,0xDF,0xFB,0x00,0x6F,0xFA,0x00,0x00,0x0F,0xFF,0x80,0x00,0x00,0x00,0x6F,0xFF,0x74,0xFF,0xF6,0x00,0x8F,0xF8,0x00,0x00,0x0F,0xFF,0x80,0x00,0x00,0x00,0xEF,0xFF,0x3D,0xFF,0xF8,0x88,0xDF,0xF8,0x00,0x00,0x0F,0xFF,0x80,0x00,0x00,0x08,0xFF,0xFE,0x8F,0xFF,0x81,0xFF,0xFF,0xF4,0x05,0xB8,0x9F,0xFF,0x80,0x00,0x00,0x5F,0xFF,0xFC,0xFF,0xFF,0x10,0x9F,0xFF,0xF2,0x00,0xAF,0xFF,0xFF,0x50,0x00,0x00,0x03,0xAF,0xF5,0x3E,0xF7,0x00,0x4F,0xFF,0x60,0x00,0x3F,0xFF,0xFF,0x10,0x00,0x00,0x00,0x01,0x80,0x01,0xA0,0x00,0x38,0x51,0x00,0x00,0x0F,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x86,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x66,0x00,0x00,0x00,0x00,0x00,0x02,0xD7,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0xA1,0x00,0x00,0x00,0x00,0x1D,0xFF,0xF8,0x10,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xFD,0x20,0x00,0x00,0x01,0xDF,0xFF,0xFF,0xFA,0x20,0x00,0x00,0x00,0x00,0x1D,0xFF,0xFF,0xF5,0x00,0x00,0x00,0x28,0xFF,0xFF,0xFF,0xFA,0x10,0x00,0x00,0x00,0x01,0xCF,0xFF,0xFF,0x30,0x00,0x00,0x00,0x18,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x0A,0xFF,0xE3,0x00,0x28,0x88,0x88,0x88,0x9F,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0xCD,0x10,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xB7,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x11,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x02,0x00,0x00,0x00,0x05,0x00,0x00,0x00,0x00,0x4F,0xFC,0xCC,0xDF,0xFF,0x80,0x00,0x2F,0x10,0x00,0x01,0xCF,0xC2,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x80,0x00,0xAF,0xD1,0x00,0x3D,0xFF,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x80,0x03,0xFF,0xFD,0x10,0x0A,0xFF,0xFF,0xFC,0x10,0x06,0xCC,0xCC,0xCC,0xBF,0xFF,0x90,0x0C,0xFF,0xFF,0x80,0x00,0x6F,0xFF,0xFF,0x90,0x08,0xFF,0xFF,0xFF,0xCF,0xFF,0xF1,0x8F,0xFF,0xF7,0x00,0x00,0x03,0xFF,0xF6,0x00,0x08,0xFF,0xFF,0xFF,0xCF,0xFF,0xFC,0xFF,0xFD,0x20,0x00,0x00,0x00,0x3E,0x30,0x00,0x04,0x88,0x8F,0xFF,0x8F,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0x6F,0xFF,0xFF,0xE2,0x00,0x00,0x00,0x00,0x00,0x03,0x10,0x00,0x00,0x00,0x8F,0xFE,0x4F,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x0B,0xE6,0x10,0x00,0x00,0xEF,0xFA,0x4F,0xFF,0xFF,0xFE,0x10,0x00,0x00,0x00,0x00,0x0F,0xFF,0xF1,0x00,0x04,0xFF,0xF5,0x4F,0xFF,0xFF,0xFF,0xB0,0x00,0x00,0x00,0x00,0x4F,0xFF,0xB0,0x00,0x0D,0xFF,0xE0,0x4F,0xFF,0x8D,0xFF,0xFA,0x00,0x00,0x00,0x00,0x9F,0xFF,0x60,0x00,0x8F,0xFF,0x80,0x4F,0xFF,0x83,0xFF,0xFF,0xA1,0x00,0x00,0x00,0xFF,0xFF,0x10,0x06,0xFF,0xFF,0x10,0x4F,0xFF,0x80,0x6F,0xFF,0xFD,0x40,0x00,0x06,0xFF,0xFA,0x00,0x7F,0xFF,0xF5,0x00,0x4F,0xFF,0x80,0x0A,0xFF,0xFF,0xFA,0x00,0x0C,0xFF,0xF5,0x2B,0xFF,0xFF,0xB0,0x00,0x4F,0xFF,0x80,0x00,0xBF,0xFF,0xF6,0x00,0x6F,0xFF,0xF1,0xDF,0xFF,0xFD,0x10,0x00,0x4F,0xFF,0x80,0x00,0x1D,0xFF,0x80,0x01,0xFF,0xFF,0xA0,0x0A,0xFF,0xD1,0x08,0xFC,0xEF,0xFF,0x80,0x00,0x01,0xBF,0x10,0x1D,0xFF,0xFF,0x50,0x00,0x7C,0x10,0x00,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x04,0x00,0x03,0xAF,0xFF,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x01,0x69,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xB3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0x41,0x00,0x00,0x00,0x00,0x00,0x00};

const uint8_t t_16_3[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xC3,0x00,0x00,0x4E,0x71,0x00,0x00,0x0C,0xFF,0x70,0x01,0xBF,0xFF,0x81,0x00,0x01,0xAF,0xD1,0x44,0x48,0xFF,0x60,0x00,0x00,0x07,0x00,0xCF,0xFF,0xF8,0x01,0x00,0x09,0x50,0x00,0x68,0x8E,0xF4,0x0C,0x40,0x8F,0xFA,0x12,0x88,0x8E,0xF5,0x4F,0xF3,0x08,0xFD,0x34,0xFF,0xFF,0xFC,0xFF,0x80,0x00,0x51,0x01,0x4C,0xFF,0xFF,0xD3,0x00,0x00,0x56,0x00,0x0E,0xFC,0xFF,0xD1,0x00,0x00,0xAF,0x90,0x6F,0xAC,0xFE,0xFA,0x00,0x00,0xFF,0x23,0xFF,0x2C,0xF5,0xEF,0xB2,0x06,0xFD,0x4F,0xF9,0x0C,0xF4,0x3F,0xFB,0x1E,0xF8,0xAF,0xD4,0x8E,0xF4,0x03,0xF3,0x6E,0xF2,0x04,0x10,0xEF,0xF3,0x00,0x20,0x00,0x50,0x00,0x00,0x7B,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x41,0x00,0x00,0x02,0xD8,0x00,0x00,0x0C,0xF4,0x00,0x00,0x07,0xFF,0xB1,0x00,0x0C,0xF4,0x00,0x00,0x00,0x6F,0xB2,0xFF,0x0C,0xF4,0x00,0x20,0x00,0x04,0x00,0xFF,0x0C,0xF9,0xAF,0x80,0x1A,0xB1,0x00,0xFF,0x6E,0xFF,0xFF,0x80,0x4F,0xFE,0x57,0xFF,0xFF,0xF9,0xAF,0x80,0x03,0xFC,0xAF,0xFF,0x7D,0xF4,0x8F,0x80,0x00,0x20,0x39,0xFF,0x0C,0xF4,0x8F,0x80,0x00,0x5B,0x40,0xFF,0x0C,0xFA,0xCF,0x80,0x00,0x9F,0x90,0xFF,0x0C,0xFC,0xFF,0x40,0x00,0xEF,0x30,0xFF,0x0C,0xF6,0x75,0x10,0x06,0xFE,0x00,0xFF,0x0C,0xC3,0x08,0xF7,0x1F,0xF9,0x00,0xFF,0xDC,0xCC,0xCF,0xFA,0x27,0xE3,0x00,0xAF,0xFF,0xFF,0xFF,0xF3,0x00,0x01,0x00,0x04,0x44,0x44,0x44,0x10,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x06,0xC1,0x04,0xD7,0x00,0x4F,0xB0,0x00,0x1D,0xFD,0x21,0xFE,0x00,0x9F,0x94,0x41,0x01,0xDF,0xD8,0xDC,0x90,0xEF,0xFF,0xF4,0x00,0x33,0xFF,0xFF,0xF7,0xFB,0x88,0x82,0x1A,0x30,0x4F,0xD4,0x7F,0xF9,0x88,0x84,0x9F,0xF6,0x0F,0xFC,0xFF,0xFF,0xFF,0xF8,0x0A,0xF8,0x0F,0xFF,0xF5,0x01,0xDF,0x70,0x00,0x40,0x1F,0x98,0xF5,0x0A,0xF9,0x01,0x00,0x83,0x4F,0x88,0xFD,0xFF,0xFF,0xF4,0x00,0xFF,0x8F,0x59,0xF9,0xCE,0xFD,0xC3,0x05,0xFB,0xBF,0x2C,0xF0,0x08,0xF4,0x00,0x0A,0xF8,0xFE,0x0C,0xD0,0x08,0xF4,0x00,0x3F,0xFC,0xF9,0xCF,0xC2,0x5B,0xF4,0x00,0x8E,0xED,0xE1,0xCF,0x80,0xCF,0xF3,0x00,0x00,0x30,0x30,0x42,0x00,0x6C,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xC3,0x00,0x00,0x4E,0x71,0x00,0x00,0x0C,0xFF,0x70,0x01,0xBF,0xFF,0x81,0x00,0x01,0xAF,0xD1,0x44,0x48,0xFF,0x60,0x00,0x00,0x07,0x00,0xCF,0xFF,0xF8,0x01,0x00,0x09,0x50,0x00,0x68,0x8E,0xF4,0x0C,0x40,0x8F,0xFA,0x12,0x88,0x8E,0xF5,0x4F,0xF3,0x08,0xFD,0x34,0xFF,0xFF,0xFC,0xFF,0x80,0x00,0x51,0x01,0x4C,0xFF,0xFF,0xD3,0x00,0x00,0x56,0x00,0x0E,0xFC,0xFF,0xD1,0x00,0x00,0xAF,0x90,0x6F,0xAC,0xFE,0xFA,0x00,0x00,0xFF,0x23,0xFF,0x2C,0xF5,0xEF,0xB2,0x06,0xFD,0x4F,0xF9,0x0C,0xF4,0x3F,0xFB,0x1E,0xF8,0xAF,0xD4,0x8E,0xF4,0x03,0xF3,0x6E,0xF2,0x04,0x10,0xEF,0xF3,0x00,0x20,0x00,0x50,0x00,0x00,0x7B,0x50,0x00,0x00};
const uint8_t t_24_3[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x10,0x00,0x00,0x00,0x03,0x40,0x00,0x00,0x00,0x00,0x00,0x5F,0xD3,0x00,0x00,0x00,0x3F,0xFC,0x60,0x00,0x00,0x00,0x04,0xFF,0xFF,0x60,0x00,0x01,0xEF,0xFF,0xFE,0x60,0x00,0x00,0x00,0x6F,0xFF,0xF9,0x00,0x00,0x18,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x06,0xFF,0xD3,0x04,0x88,0x88,0x9F,0xFF,0x60,0x00,0x00,0x00,0x00,0x6B,0x10,0x08,0xFF,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x08,0xFF,0xFF,0xFF,0xF0,0x00,0x90,0x00,0x06,0xF9,0x10,0x00,0x02,0x44,0x44,0xFF,0xF0,0x04,0xFA,0x00,0x6F,0xFF,0xE4,0x00,0x14,0x44,0x44,0xFF,0xF0,0x0C,0xFF,0x80,0x1A,0xFF,0xFF,0x70,0x4F,0xFF,0xFF,0xFF,0xF2,0x7F,0xFF,0xC1,0x00,0x7F,0xFA,0x00,0x4F,0xFF,0xFF,0xFF,0xFC,0xFF,0xF7,0x00,0x00,0x06,0x60,0x00,0x28,0x8F,0xFC,0xFF,0xFF,0xFC,0x20,0x00,0x00,0x00,0x10,0x00,0x00,0x2F,0xF9,0xFF,0xFF,0xE0,0x00,0x00,0x00,0x02,0xE6,0x10,0x00,0x7F,0xF6,0xFF,0xFF,0xF8,0x00,0x00,0x00,0x06,0xFF,0xE0,0x00,0xEF,0xF1,0xFF,0xFF,0xFF,0x50,0x00,0x00,0x0A,0xFF,0x90,0x07,0xFF,0xA0,0xFF,0xF8,0xFF,0xF5,0x00,0x00,0x1F,0xFF,0x20,0x6F,0xFF,0x20,0xFF,0xF0,0xCF,0xFF,0x81,0x00,0x6F,0xFD,0x07,0xFF,0xF9,0x00,0xFF,0xF0,0x1E,0xFF,0xFB,0x00,0xEF,0xF8,0xCF,0xFF,0xD1,0x00,0xFF,0xF0,0x03,0xFF,0xF4,0x09,0xFF,0xF2,0x3E,0xFD,0x16,0xCC,0xFF,0xF0,0x00,0x3F,0xA0,0x4F,0xFF,0xD0,0x01,0xA1,0x00,0xEF,0xFF,0xF0,0x00,0x03,0x20,0x01,0x7E,0x70,0x00,0x00,0x00,0x9F,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x3B,0x72,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x60,0x00,0x00,0x00,0x04,0xFF,0xE0,0x00,0x00,0x00,0x00,0x5F,0xF9,0x00,0x00,0x00,0x04,0xFF,0xC0,0x00,0x00,0x00,0x01,0xEF,0xFF,0xC1,0x00,0x00,0x04,0xFF,0xC0,0x00,0x00,0x00,0x00,0x1D,0xFF,0xFC,0x2C,0xCC,0x24,0xFF,0xC0,0x00,0x00,0x00,0x00,0x01,0xDF,0xC1,0x0F,0xFF,0x04,0xFF,0xC0,0x00,0x14,0x00,0x00,0x00,0x19,0x00,0x0F,0xFD,0x04,0xFF,0xC2,0x6B,0xFC,0x00,0x00,0x53,0x00,0x00,0x0F,0xFC,0x04,0xFF,0xFF,0xFF,0xF9,0x00,0x06,0xFF,0x70,0x00,0x0F,0xFD,0x9D,0xFF,0xFF,0xFF,0xF8,0x00,0x2F,0xFF,0xFC,0x20,0x3F,0xFF,0xFF,0xFF,0xFA,0x8F,0xF8,0x00,0x03,0xDF,0xFF,0xEF,0xFF,0xFF,0xFF,0xFF,0xC0,0x4F,0xF8,0x00,0x00,0x1D,0xF6,0x4F,0xFF,0xFE,0x54,0xFF,0xC0,0x4F,0xFB,0x00,0x00,0x01,0x40,0x0F,0xBF,0xFC,0x04,0xFF,0xC0,0x4F,0xFC,0x00,0x00,0x00,0x60,0x01,0x0F,0xFC,0x04,0xFF,0xC0,0x4F,0xFC,0x00,0x00,0x00,0xFE,0x81,0x0F,0xFC,0x04,0xFF,0xFC,0xEF,0xFC,0x00,0x00,0x05,0xFF,0xE0,0x0F,0xFC,0x04,0xFF,0xCE,0xFF,0xF8,0x00,0x00,0x0A,0xFF,0x90,0x0F,0xFC,0x04,0xFF,0xC8,0xFF,0x80,0x00,0x00,0x0F,0xFF,0x30,0x0F,0xFC,0x04,0xFF,0xF1,0x30,0x81,0x00,0x00,0x6F,0xFE,0x00,0x0F,0xFC,0x06,0xFF,0xF0,0x00,0xCF,0xA4,0x01,0xEF,0xF9,0x00,0x0F,0xFF,0x30,0x00,0x00,0x01,0xFF,0xFB,0x0B,0xFF,0xF3,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF6,0x26,0xDF,0xE0,0x00,0x0A,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xE1,0x00,0x04,0x60,0x00,0x01,0xAC,0xCC,0xCC,0xCC,0xCC,0xCB,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x00,0x00,0x02,0x60,0x00,0x00,0x99,0x30,0x00,0x00,0x00,0xAF,0x80,0x00,0x9F,0xF5,0x00,0x00,0xEF,0xF6,0x00,0x00,0x08,0xFF,0xFA,0x00,0x3F,0xFB,0x00,0x03,0xFF,0xC0,0x00,0x00,0x00,0xAF,0xFF,0xD0,0x0E,0xFC,0x00,0x09,0xFF,0xEC,0xCC,0x90,0x00,0x0A,0xFF,0xFC,0xCF,0xCC,0xEC,0x1F,0xFF,0xFF,0xFF,0xC0,0x00,0x01,0xB1,0xFF,0xFF,0xFF,0xFC,0x8F,0xFD,0xCC,0xCC,0x90,0x00,0x20,0x00,0xCE,0xFF,0xCC,0xCB,0xFF,0xD0,0x00,0x00,0x00,0x0A,0xF5,0x00,0x08,0xFF,0x00,0x1D,0xFF,0xE9,0x88,0x88,0x82,0x8F,0xFF,0xA1,0x08,0xFF,0x88,0xDF,0xFF,0xFF,0xFF,0xFF,0xF4,0x1B,0xFF,0xFC,0x08,0xFF,0xFF,0xFF,0xA9,0x88,0x9F,0xFF,0xA2,0x00,0xAF,0xD1,0x08,0xFF,0xFF,0xFF,0x00,0x01,0xDF,0xF6,0x00,0x00,0x07,0x00,0x0A,0xFF,0x0C,0xFC,0x00,0x0F,0xFF,0x90,0x00,0x00,0x01,0x00,0x0C,0xFD,0x0C,0xFC,0xB8,0x8F,0xFF,0x88,0xC0,0x00,0x0A,0xA4,0x0F,0xFC,0x0C,0xFB,0xFF,0xFF,0xFF,0xFF,0xF0,0x00,0x0E,0xFF,0x3F,0xF9,0x0F,0xF8,0xFF,0xFF,0xFF,0xFF,0xF0,0x00,0x3F,0xFD,0x5F,0xF6,0x0F,0xF8,0x20,0x0C,0xFF,0x00,0x20,0x00,0x8F,0xF7,0xAF,0xF2,0x0F,0xF7,0x00,0x0C,0xFF,0x00,0x00,0x00,0xEF,0xF3,0xFF,0xE0,0x2F,0xF4,0x00,0x0C,0xFF,0x00,0x00,0x06,0xFF,0xE8,0xFF,0xA4,0x7F,0xF4,0x00,0x0C,0xFF,0x00,0x00,0x1E,0xFF,0xCF,0xFF,0x5F,0xFF,0xF1,0x49,0x8F,0xFF,0x00,0x00,0x8F,0xFF,0xDF,0xF8,0x0A,0xFF,0xE0,0x0C,0xFF,0xFD,0x00,0x00,0x02,0x8E,0x06,0xE1,0x08,0xFA,0x20,0x05,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x01,0xCB,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x10,0x00,0x00,0x00,0x03,0x40,0x00,0x00,0x00,0x00,0x00,0x5F,0xD3,0x00,0x00,0x00,0x3F,0xFC,0x60,0x00,0x00,0x00,0x04,0xFF,0xFF,0x60,0x00,0x01,0xEF,0xFF,0xFE,0x60,0x00,0x00,0x00,0x6F,0xFF,0xF9,0x00,0x00,0x18,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x06,0xFF,0xD3,0x04,0x88,0x88,0x9F,0xFF,0x60,0x00,0x00,0x00,0x00,0x6B,0x10,0x08,0xFF,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x08,0xFF,0xFF,0xFF,0xF0,0x00,0x90,0x00,0x06,0xF9,0x10,0x00,0x02,0x44,0x44,0xFF,0xF0,0x04,0xFA,0x00,0x6F,0xFF,0xE4,0x00,0x14,0x44,0x44,0xFF,0xF0,0x0C,0xFF,0x80,0x1A,0xFF,0xFF,0x70,0x4F,0xFF,0xFF,0xFF,0xF2,0x7F,0xFF,0xC1,0x00,0x7F,0xFA,0x00,0x4F,0xFF,0xFF,0xFF,0xFC,0xFF,0xF7,0x00,0x00,0x06,0x60,0x00,0x28,0x8F,0xFC,0xFF,0xFF,0xFC,0x20,0x00,0x00,0x00,0x10,0x00,0x00,0x2F,0xF9,0xFF,0xFF,0xE0,0x00,0x00,0x00,0x02,0xE6,0x10,0x00,0x7F,0xF6,0xFF,0xFF,0xF8,0x00,0x00,0x00,0x06,0xFF,0xE0,0x00,0xEF,0xF1,0xFF,0xFF,0xFF,0x50,0x00,0x00,0x0A,0xFF,0x90,0x07,0xFF,0xA0,0xFF,0xF8,0xFF,0xF5,0x00,0x00,0x1F,0xFF,0x20,0x6F,0xFF,0x20,0xFF,0xF0,0xCF,0xFF,0x81,0x00,0x6F,0xFD,0x07,0xFF,0xF9,0x00,0xFF,0xF0,0x1E,0xFF,0xFB,0x00,0xEF,0xF8,0xCF,0xFF,0xD1,0x00,0xFF,0xF0,0x03,0xFF,0xF4,0x09,0xFF,0xF2,0x3E,0xFD,0x16,0xCC,0xFF,0xF0,0x00,0x3F,0xA0,0x4F,0xFF,0xD0,0x01,0xA1,0x00,0xEF,0xFF,0xF0,0x00,0x03,0x20,0x01,0x7E,0x70,0x00,0x00,0x00,0x9F,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x3B,0x72,0x00,0x00,0x00,0x00};
const uint8_t t_32_3[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6A,0x00,0x00,0x00,0x00,0x00,0x03,0xEA,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xD2,0x00,0x00,0x00,0x00,0x1D,0xFF,0xFA,0x40,0x00,0x00,0x00,0x00,0x00,0xAF,0xFF,0xFF,0x40,0x00,0x00,0x01,0xDF,0xFF,0xFF,0xFC,0x40,0x00,0x00,0x00,0x00,0x3F,0xFF,0xFF,0xF8,0x00,0x00,0x00,0x4C,0xFF,0xFF,0xFF,0xFD,0x30,0x00,0x00,0x00,0x03,0xDF,0xFF,0xFF,0x40,0x00,0x00,0x00,0x2B,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x1D,0xFF,0xF3,0x00,0x3C,0xCA,0x88,0x88,0xCF,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x01,0xED,0x10,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xE7,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x31,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x03,0x00,0x00,0x00,0x18,0x10,0x00,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x4F,0x30,0x00,0x01,0xDF,0xE4,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xFF,0xC0,0x00,0xCF,0xD1,0x00,0x3E,0xFF,0xFF,0x91,0x00,0x00,0x00,0x00,0x00,0x8F,0xFF,0xC0,0x04,0xFF,0xFD,0x10,0x1C,0xFF,0xFF,0xFE,0x30,0x06,0xCC,0xCC,0xCC,0xEF,0xFF,0xC0,0x1E,0xFF,0xFF,0xC0,0x00,0x9F,0xFF,0xFF,0x90,0x08,0xFF,0xFF,0xFF,0xFF,0xFF,0xF2,0xAF,0xFF,0xFB,0x10,0x00,0x06,0xFF,0xF6,0x00,0x08,0xFF,0xFF,0xFF,0xFF,0xFF,0xFD,0xFF,0xFF,0x50,0x00,0x00,0x00,0x6F,0x30,0x00,0x06,0xCC,0xDF,0xFF,0xFF,0xFF,0xFF,0xFF,0xB1,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x6F,0xFF,0xCF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x06,0x10,0x00,0x00,0x00,0xAF,0xFF,0x8F,0xFF,0xFF,0xF7,0x00,0x00,0x00,0x00,0x00,0x0E,0xE6,0x10,0x00,0x00,0xFF,0xFB,0x8F,0xFF,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x2F,0xFF,0xF3,0x00,0x06,0xFF,0xF7,0x8F,0xFF,0xFF,0xFF,0xD1,0x00,0x00,0x00,0x00,0x6F,0xFF,0xE0,0x00,0x1F,0xFF,0xF1,0x8F,0xFF,0xDF,0xFF,0xFD,0x10,0x00,0x00,0x00,0xBF,0xFF,0x90,0x00,0xAF,0xFF,0xA0,0x8F,0xFF,0xC4,0xFF,0xFF,0xD2,0x00,0x00,0x01,0xFF,0xFF,0x20,0x0A,0xFF,0xFF,0x20,0x8F,0xFF,0xC0,0x9F,0xFF,0xFF,0x60,0x00,0x08,0xFF,0xFD,0x01,0xAF,0xFF,0xF8,0x00,0x8F,0xFF,0xC0,0x0C,0xFF,0xFF,0xFB,0x00,0x1F,0xFF,0xF7,0x4D,0xFF,0xFF,0xD0,0x00,0x8F,0xFF,0xC0,0x01,0xDF,0xFF,0xF6,0x00,0x8F,0xFF,0xF3,0xDF,0xFF,0xFF,0x24,0x00,0x8F,0xFF,0xC0,0x00,0x1D,0xFF,0xA0,0x03,0xFF,0xFF,0xD0,0x09,0xFF,0xF3,0x08,0xFF,0xFF,0xFF,0xC0,0x00,0x01,0xDF,0x10,0x3F,0xFF,0xFF,0x70,0x00,0x6E,0x30,0x01,0xFF,0xFF,0xFF,0xB0,0x00,0x00,0x17,0x00,0x03,0xAF,0xFF,0x20,0x00,0x01,0x00,0x00,0x9F,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x01,0x7B,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xE6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0B,0x83,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x9C,0xCC,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0x60,0x00,0x00,0x00,0x00,0x00,0x9F,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xFA,0x00,0x00,0x00,0x00,0x00,0x8F,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x7F,0xFF,0xFF,0xD1,0x00,0x00,0x00,0x00,0x8F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x07,0xFF,0xFF,0xFF,0x31,0x44,0x44,0x10,0x8F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFF,0xFF,0x43,0xFF,0xFF,0x20,0x8F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0xD1,0x00,0xFF,0xFF,0x00,0x8F,0xFF,0x40,0x00,0x02,0x70,0x00,0x00,0x00,0x00,0x7A,0x00,0x00,0xFF,0xFD,0x00,0x8F,0xFF,0x40,0x27,0xDF,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0xFC,0x00,0x8F,0xFF,0xBE,0xFF,0xFF,0xC0,0x00,0x00,0x1D,0xA1,0x00,0x00,0x00,0xFF,0xFC,0x00,0xAF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x03,0xDF,0xFE,0x40,0x00,0x00,0xFF,0xFE,0xAF,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x1E,0xFF,0xFF,0xF9,0x10,0x01,0xFF,0xFF,0xFF,0xFF,0xFF,0xFD,0x7F,0xFF,0xC0,0x00,0x02,0xDF,0xFF,0xFF,0xD7,0xBF,0xFF,0xFF,0xFF,0xFF,0xFF,0x50,0x0F,0xFF,0xC0,0x00,0x00,0x1A,0xFF,0xFF,0x9F,0xFF,0xFF,0xFF,0xFD,0xCF,0xFF,0x40,0x0F,0xFF,0xC0,0x00,0x00,0x00,0xAF,0xD3,0x0F,0xFF,0xFF,0xFD,0x20,0x8F,0xFF,0x40,0x0F,0xFF,0xC0,0x00,0x00,0x00,0x08,0x10,0x0B,0xFE,0xFF,0xFC,0x00,0x8F,0xFF,0x40,0x0F,0xFF,0xF0,0x00,0x00,0x00,0x01,0x00,0x05,0x40,0xFF,0xFC,0x00,0x8F,0xFF,0x40,0x0F,0xFF,0xF0,0x00,0x00,0x00,0x08,0xB2,0x00,0x00,0xFF,0xFC,0x00,0x8F,0xFF,0x40,0x2F,0xFF,0xF0,0x00,0x00,0x00,0x0C,0xFF,0xB4,0x00,0xFF,0xFC,0x00,0x8F,0xFF,0xFF,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x0F,0xFF,0xF5,0x00,0xFF,0xFC,0x00,0x8F,0xFF,0x8F,0xFF,0xFF,0xB0,0x00,0x00,0x00,0x5F,0xFF,0xF0,0x00,0xFF,0xFC,0x00,0x8F,0xFF,0x7D,0xFF,0xFE,0x30,0x00,0x00,0x00,0xAF,0xFF,0xA0,0x00,0xFF,0xFC,0x00,0xAF,0xFF,0x88,0xFC,0x72,0x00,0x00,0x00,0x01,0xFF,0xFF,0x40,0x00,0xFF,0xFC,0x00,0xCF,0xFF,0x80,0x00,0x0C,0x20,0x00,0x00,0x08,0xFF,0xFF,0x00,0x00,0xFF,0xFC,0x00,0xCF,0xFF,0xC0,0x00,0x0F,0xFA,0x50,0x00,0x1F,0xFF,0xFA,0x00,0x00,0xFF,0xFE,0x00,0x44,0x44,0x30,0x00,0x2F,0xFF,0xFC,0x00,0xAF,0xFF,0xF5,0x00,0x00,0xFF,0xFF,0xB8,0x88,0x88,0x88,0x88,0xBF,0xFF,0xF8,0x06,0xFF,0xFF,0xF0,0x00,0x00,0xEF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF2,0x16,0xCF,0xFF,0xA0,0x00,0x00,0xAF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xA0,0x00,0x02,0xAF,0x50,0x00,0x00,0x1E,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFD,0x10,0x00,0x00,0x01,0x00,0x00,0x00,0x01,0x44,0x44,0x44,0x44,0x44,0x44,0x44,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x50,0x00,0x00,0x00,0x00,0x00,0x02,0xB2,0x00,0x00,0x04,0x8C,0xC0,0x00,0x00,0x05,0xFF,0xA5,0x10,0x00,0x00,0x00,0x3F,0xFF,0x30,0x00,0x0B,0xFF,0xF2,0x00,0x00,0x09,0xFF,0xFA,0x00,0x00,0x00,0x03,0xFF,0xFF,0xF6,0x00,0x05,0xFF,0xF9,0x00,0x00,0x0E,0xFF,0xF1,0x00,0x00,0x00,0x00,0x6F,0xFF,0xFF,0x80,0x00,0xFF,0xFE,0x00,0x00,0x3F,0xFF,0xC4,0x44,0x58,0x40,0x00,0x06,0xFF,0xFF,0xF5,0x00,0xAD,0x84,0x34,0x10,0xAF,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x6F,0xFD,0xFF,0xFF,0xFF,0xFF,0xFF,0x41,0xFF,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x0A,0xA1,0xFF,0xFF,0xFF,0xFF,0xFF,0x48,0xFF,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x01,0x00,0xFF,0xFF,0xFF,0xFF,0xFF,0x6F,0xFF,0xA0,0x00,0x00,0x00,0x00,0x00,0x36,0x00,0x00,0x85,0xFF,0xF7,0x44,0x68,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x06,0xFF,0x90,0x00,0x00,0xFF,0xF4,0x00,0x0A,0xFF,0xFF,0xDC,0xCC,0xCC,0xCC,0xC0,0x7F,0xFF,0xFD,0x20,0x00,0xFF,0xF7,0x44,0xAF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF0,0x1D,0xFF,0xFF,0xF5,0x00,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF0,0x01,0xCF,0xFF,0xF9,0x00,0xFF,0xFF,0xFF,0xFF,0xA3,0x20,0x00,0x3E,0xFF,0xF8,0x10,0x00,0x0A,0xFF,0x60,0x00,0xFF,0xFD,0xCF,0xFF,0x80,0x00,0x03,0xFF,0xFF,0x60,0x00,0x00,0x00,0xB3,0x00,0x04,0xFF,0xF4,0x0F,0xFF,0x80,0x00,0x5F,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xF4,0x0F,0xFF,0x54,0x00,0x4F,0xFF,0xE0,0x14,0x30,0x00,0x00,0x53,0x00,0x07,0xFF,0xF1,0x0F,0xFF,0x8F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x9F,0xA4,0x09,0xFF,0xF0,0x1F,0xFF,0x8F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0xDF,0xFF,0x3C,0xFF,0xC0,0x4F,0xFF,0x5F,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x02,0xFF,0xFE,0x0F,0xFF,0xA0,0x4F,0xFF,0x28,0x84,0x4F,0xFF,0xA5,0x88,0x60,0x00,0x06,0xFF,0xF9,0x4F,0xFF,0x70,0x4F,0xFF,0x00,0x00,0x0F,0xFF,0x80,0x00,0x00,0x00,0x0B,0xFF,0xF3,0x9F,0xFF,0x20,0x7F,0xFD,0x00,0x00,0x0F,0xFF,0x80,0x00,0x00,0x00,0x2F,0xFF,0xF1,0xFF,0xFE,0x00,0x8F,0xFC,0x00,0x00,0x0F,0xFF,0x80,0x00,0x00,0x00,0x8F,0xFF,0xA6,0xFF,0xF9,0x00,0x9F,0xFB,0x00,0x00,0x0F,0xFF,0x80,0x00,0x00,0x01,0xFF,0xFF,0x6F,0xFF,0xFA,0x99,0xFF,0xF8,0x01,0x00,0x0F,0xFF,0x80,0x00,0x00,0x0B,0xFF,0xFF,0xCF,0xFF,0xA2,0xFF,0xFF,0xF8,0x04,0xD9,0xBF,0xFF,0x80,0x00,0x00,0x8F,0xFF,0xFE,0xFF,0xFF,0x20,0xAF,0xFF,0xF3,0x00,0xBF,0xFF,0xFF,0x80,0x00,0x00,0x04,0xAF,0xF7,0x3F,0xF9,0x00,0x5F,0xFF,0x90,0x00,0x4F,0xFF,0xFF,0x30,0x00,0x00,0x00,0x01,0x82,0x01,0xC1,0x00,0x3B,0x72,0x00,0x00,0x0F,0xFF,0xF9,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x09,0xC8,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6A,0x00,0x00,0x00,0x00,0x00,0x03,0xEA,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0xD2,0x00,0x00,0x00,0x00,0x1D,0xFF,0xFA,0x40,0x00,0x00,0x00,0x00,0x00,0xAF,0xFF,0xFF,0x40,0x00,0x00,0x01,0xDF,0xFF,0xFF,0xFC,0x40,0x00,0x00,0x00,0x00,0x3F,0xFF,0xFF,0xF8,0x00,0x00,0x00,0x4C,0xFF,0xFF,0xFF,0xFD,0x30,0x00,0x00,0x00,0x03,0xDF,0xFF,0xFF,0x40,0x00,0x00,0x00,0x2B,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x00,0x00,0x1D,0xFF,0xF3,0x00,0x3C,0xCA,0x88,0x88,0xCF,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x01,0xED,0x10,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xE7,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x31,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x03,0x00,0x00,0x00,0x18,0x10,0x00,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x4F,0x30,0x00,0x01,0xDF,0xE4,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xFF,0xC0,0x00,0xCF,0xD1,0x00,0x3E,0xFF,0xFF,0x91,0x00,0x00,0x00,0x00,0x00,0x8F,0xFF,0xC0,0x04,0xFF,0xFD,0x10,0x1C,0xFF,0xFF,0xFE,0x30,0x06,0xCC,0xCC,0xCC,0xEF,0xFF,0xC0,0x1E,0xFF,0xFF,0xC0,0x00,0x9F,0xFF,0xFF,0x90,0x08,0xFF,0xFF,0xFF,0xFF,0xFF,0xF2,0xAF,0xFF,0xFB,0x10,0x00,0x06,0xFF,0xF6,0x00,0x08,0xFF,0xFF,0xFF,0xFF,0xFF,0xFD,0xFF,0xFF,0x50,0x00,0x00,0x00,0x6F,0x30,0x00,0x06,0xCC,0xDF,0xFF,0xFF,0xFF,0xFF,0xFF,0xB1,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x6F,0xFF,0xCF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0x00,0x06,0x10,0x00,0x00,0x00,0xAF,0xFF,0x8F,0xFF,0xFF,0xF7,0x00,0x00,0x00,0x00,0x00,0x0E,0xE6,0x10,0x00,0x00,0xFF,0xFB,0x8F,0xFF,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x2F,0xFF,0xF3,0x00,0x06,0xFF,0xF7,0x8F,0xFF,0xFF,0xFF,0xD1,0x00,0x00,0x00,0x00,0x6F,0xFF,0xE0,0x00,0x1F,0xFF,0xF1,0x8F,0xFF,0xDF,0xFF,0xFD,0x10,0x00,0x00,0x00,0xBF,0xFF,0x90,0x00,0xAF,0xFF,0xA0,0x8F,0xFF,0xC4,0xFF,0xFF,0xD2,0x00,0x00,0x01,0xFF,0xFF,0x20,0x0A,0xFF,0xFF,0x20,0x8F,0xFF,0xC0,0x9F,0xFF,0xFF,0x60,0x00,0x08,0xFF,0xFD,0x01,0xAF,0xFF,0xF8,0x00,0x8F,0xFF,0xC0,0x0C,0xFF,0xFF,0xFB,0x00,0x1F,0xFF,0xF7,0x4D,0xFF,0xFF,0xD0,0x00,0x8F,0xFF,0xC0,0x01,0xDF,0xFF,0xF6,0x00,0x8F,0xFF,0xF3,0xDF,0xFF,0xFF,0x24,0x00,0x8F,0xFF,0xC0,0x00,0x1D,0xFF,0xA0,0x03,0xFF,0xFF,0xD0,0x09,0xFF,0xF3,0x08,0xFF,0xFF,0xFF,0xC0,0x00,0x01,0xDF,0x10,0x3F,0xFF,0xFF,0x70,0x00,0x6E,0x30,0x01,0xFF,0xFF,0xFF,0xB0,0x00,0x00,0x17,0x00,0x03,0xAF,0xFF,0x20,0x00,0x01,0x00,0x00,0x9F,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x01,0x7B,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xE6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0B,0x83,0x00,0x00,0x00,0x00,0x00,0x00};

const uint8_t t_18_1[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x51,0x00,0x00,0x01,0x92,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFE,0x30,0x00,0x0A,0xFF,0xA2,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xF6,0x00,0x00,0x2B,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x06,0xB1,0x06,0x88,0x88,0x86,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0x80,0x02,0x00,0x00,0x00,0x00,0x0A,0x70,0x00,0x00,0x00,0x4F,0x80,0x1E,0x30,0x00,0x00,0x00,0x3D,0xFC,0x20,0x24,0x44,0x5F,0x80,0x9F,0xB0,0x00,0x00,0x00,0x01,0xAF,0x60,0x8F,0xFF,0x8F,0xE6,0xF9,0x00,0x00,0x00,0x00,0x00,0x03,0x00,0x24,0xAF,0x4F,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x04,0x00,0x00,0xBD,0x4F,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0x0F,0xC0,0x01,0xF9,0x4F,0xAF,0xC0,0x00,0x00,0x00,0x00,0x00,0x3F,0x90,0x0B,0xF2,0x4F,0x87,0xFA,0x00,0x00,0x00,0x00,0x00,0xAF,0x20,0x6F,0x90,0x4F,0x80,0xAF,0xC2,0x00,0x00,0x00,0x01,0xFD,0x19,0xFD,0x10,0x4F,0x80,0x1D,0xF6,0x00,0x00,0x00,0x0B,0xF7,0x2B,0xD1,0x18,0xAF,0x80,0x01,0x80,0x00,0x00,0x00,0x1A,0xF2,0x00,0x10,0x0D,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x04,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x64,0x00,0x00,0x00,0x5F,0x40,0x00,0x00,0x00,0x00,0x00,0x01,0xFF,0x70,0x00,0x00,0x4F,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xF8,0x08,0x60,0x4F,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x90,0x0F,0xA0,0x4F,0x40,0x05,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x0F,0x80,0x4F,0x8A,0xFF,0x00,0x00,0x00,0x00,0x1A,0xD3,0x00,0x0F,0x96,0xCF,0xFE,0xFF,0x00,0x00,0x00,0x00,0x07,0xFF,0x72,0x7F,0xFF,0xFF,0x60,0xCF,0x00,0x00,0x00,0x00,0x00,0x5E,0x4E,0xFF,0xC3,0x4F,0x40,0xCF,0x00,0x00,0x00,0x00,0x00,0x01,0x05,0x3F,0x80,0x4F,0x40,0xCF,0x00,0x00,0x00,0x00,0x00,0x06,0x50,0x0F,0x80,0x4F,0x41,0xDF,0x00,0x00,0x00,0x00,0x00,0x0E,0xE0,0x0F,0x80,0x4F,0x7F,0xFC,0x00,0x00,0x00,0x00,0x00,0x3F,0x90,0x0F,0x80,0x4F,0x47,0x71,0x00,0x00,0x00,0x00,0x00,0xAF,0x30,0x0F,0x80,0x8F,0x70,0x05,0x40,0x00,0x00,0x00,0x02,0xFE,0x00,0x0F,0xB0,0x00,0x00,0x0A,0xF6,0x00,0x00,0x00,0x0B,0xF9,0x00,0x0E,0xFD,0xCC,0xCC,0xCF,0xF2,0x00,0x00,0x00,0x02,0xA3,0x00,0x04,0xCC,0xCC,0xCC,0xCC,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x50,0x00,0x4B,0x10,0x00,0x7A,0x20,0x00,0x00,0x00,0x00,0x07,0xFA,0x00,0x2F,0x70,0x00,0xDD,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xC0,0x0A,0x60,0x02,0xFC,0x88,0x80,0x00,0x00,0x00,0x00,0x0B,0xBC,0xCC,0xCE,0x4A,0xFC,0xCC,0xC0,0x00,0x00,0x00,0x00,0x00,0x48,0xFA,0x88,0x5F,0x60,0x00,0x00,0x00,0x00,0x00,0x1C,0x40,0x00,0xF4,0x01,0xDF,0x88,0x88,0x80,0x00,0x00,0x00,0x3E,0xF8,0x00,0xFA,0x8A,0xD8,0xA8,0xBF,0xE0,0x00,0x00,0x00,0x01,0xDC,0x13,0xFD,0xDF,0x30,0x01,0xDD,0x10,0x00,0x00,0x00,0x00,0x10,0x04,0xF4,0x4F,0x00,0x0D,0xF1,0x00,0x00,0x00,0x00,0x00,0x13,0x05,0xF1,0x5F,0x69,0x8E,0xE8,0xB3,0x00,0x00,0x00,0x00,0x5F,0x58,0xF0,0x8F,0x6C,0xCF,0xFC,0xC3,0x00,0x00,0x00,0x00,0xAF,0x0C,0xC0,0x8C,0x00,0x0C,0xC0,0x00,0x00,0x00,0x00,0x00,0xFB,0x1F,0x80,0x8C,0x00,0x0C,0xC0,0x00,0x00,0x00,0x00,0x06,0xF6,0x8F,0x20,0xCB,0x00,0x0C,0xC0,0x00,0x00,0x00,0x00,0x1E,0xF3,0xFC,0x3C,0xF8,0x06,0x5F,0xC0,0x00,0x00,0x00,0x00,0x3A,0xB5,0xF2,0x0D,0xB2,0x05,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x10,0x10,0x00,0x00,0x01,0x84,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x51,0x00,0x00,0x01,0x92,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFE,0x30,0x00,0x0A,0xFF,0xA2,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xF6,0x00,0x00,0x2B,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x06,0xB1,0x06,0x88,0x88,0x86,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0x80,0x02,0x00,0x00,0x00,0x00,0x0A,0x70,0x00,0x00,0x00,0x4F,0x80,0x1E,0x30,0x00,0x00,0x00,0x3D,0xFC,0x20,0x24,0x44,0x5F,0x80,0x9F,0xB0,0x00,0x00,0x00,0x01,0xAF,0x60,0x8F,0xFF,0x8F,0xE6,0xF9,0x00,0x00,0x00,0x00,0x00,0x03,0x00,0x24,0xAF,0x4F,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x04,0x00,0x00,0xBD,0x4F,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0x0F,0xC0,0x01,0xF9,0x4F,0xAF,0xC0,0x00,0x00,0x00,0x00,0x00,0x3F,0x90,0x0B,0xF2,0x4F,0x87,0xFA,0x00,0x00,0x00,0x00,0x00,0xAF,0x20,0x6F,0x90,0x4F,0x80,0xAF,0xC2,0x00,0x00,0x00,0x01,0xFD,0x19,0xFD,0x10,0x4F,0x80,0x1D,0xF6,0x00,0x00,0x00,0x0B,0xF7,0x2B,0xD1,0x18,0xAF,0x80,0x01,0x80,0x00,0x00,0x00,0x1A,0xF2,0x00,0x10,0x0D,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x04,0x40,0x00,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_18_1_5[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x52,0x00,0x00,0x01,0x92,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0x40,0x00,0x0A,0xFF,0xC4,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xF6,0x00,0x00,0x4C,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x0A,0xB1,0x09,0xB8,0x88,0x96,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0x80,0x03,0x00,0x00,0x00,0x00,0x1A,0x80,0x00,0x00,0x00,0x4F,0x80,0x2F,0x30,0x00,0x00,0x00,0x3F,0xFD,0x30,0x48,0x88,0x6F,0x90,0xBF,0xD0,0x00,0x00,0x00,0x01,0xDF,0x70,0x8F,0xFF,0x8F,0xF7,0xFB,0x10,0x00,0x00,0x00,0x00,0x13,0x00,0x24,0xAF,0x6F,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x04,0x00,0x00,0xDE,0x4F,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x0F,0xD0,0x02,0xFA,0x4F,0xBF,0xD1,0x00,0x00,0x00,0x00,0x00,0x5F,0xA0,0x0C,0xF3,0x4F,0x88,0xFC,0x10,0x00,0x00,0x00,0x00,0xBF,0x50,0xAF,0xB0,0x4F,0x80,0xCF,0xD4,0x00,0x00,0x00,0x02,0xFE,0x2B,0xFE,0x10,0x4F,0x80,0x1D,0xF6,0x00,0x00,0x00,0x0C,0xF9,0x1B,0xE3,0x29,0xBF,0x80,0x01,0xA0,0x00,0x00,0x00,0x3A,0xF3,0x00,0x10,0x0D,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x04,0x62,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x66,0x00,0x00,0x00,0x8F,0x80,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0x90,0x00,0x00,0x8F,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xF9,0x18,0x70,0x8F,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xA0,0x0F,0xC0,0x8F,0x40,0x16,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x0F,0xC0,0x8F,0x9B,0xFF,0x00,0x00,0x00,0x00,0x1B,0xE4,0x00,0x0F,0xD7,0xEF,0xFE,0xFF,0x00,0x00,0x00,0x00,0x09,0xFF,0x93,0x8F,0xFF,0xFF,0x60,0xCF,0x00,0x00,0x00,0x00,0x00,0x6F,0x4E,0xFF,0xE5,0x8F,0x40,0xCF,0x00,0x00,0x00,0x00,0x00,0x01,0x07,0x5F,0xC0,0x8F,0x40,0xCF,0x00,0x00,0x00,0x00,0x00,0x08,0x40,0x0F,0xC0,0x8F,0x42,0xDF,0x00,0x00,0x00,0x00,0x00,0x0F,0xF1,0x0F,0xC0,0x8F,0x8F,0xFE,0x00,0x00,0x00,0x00,0x00,0x5F,0xA0,0x0F,0xC0,0x8F,0x79,0x81,0x00,0x00,0x00,0x00,0x00,0xAF,0x50,0x0F,0xC0,0x8F,0x80,0x07,0x40,0x00,0x00,0x00,0x03,0xFF,0x00,0x0F,0xD0,0x00,0x00,0x0C,0xF8,0x00,0x00,0x00,0x1D,0xFA,0x00,0x0F,0xFE,0xCC,0xCC,0xDF,0xF3,0x00,0x00,0x00,0x02,0xA5,0x00,0x06,0xCC,0xCC,0xCC,0xCC,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x70,0x00,0x4B,0x20,0x00,0xAB,0x30,0x00,0x00,0x00,0x00,0x0A,0xFC,0x10,0x3F,0x90,0x00,0xEE,0x00,0x00,0x00,0x00,0x00,0x01,0xDF,0xD1,0x0C,0x70,0x04,0xFC,0x88,0xC0,0x00,0x00,0x00,0x00,0x1C,0xBF,0xFF,0xFF,0x4C,0xFC,0xCC,0xE0,0x00,0x00,0x00,0x00,0x00,0x6C,0xFA,0x8C,0x7F,0x80,0x00,0x00,0x00,0x00,0x00,0x2C,0x60,0x04,0xF4,0x01,0xFF,0x98,0x88,0x80,0x00,0x00,0x00,0x4F,0xFA,0x04,0xFD,0xCE,0xDC,0xCC,0xEF,0xF0,0x00,0x00,0x00,0x03,0xFC,0x14,0xFD,0xDF,0x40,0x03,0xFD,0x10,0x00,0x00,0x00,0x00,0x20,0x04,0xF4,0x5F,0x30,0x0F,0xF3,0x00,0x00,0x00,0x00,0x00,0x22,0x07,0xF4,0x8F,0x6C,0xCF,0xFC,0xC3,0x00,0x00,0x00,0x00,0x7F,0x59,0xF0,0x8F,0x8D,0xCF,0xFC,0xE4,0x00,0x00,0x00,0x00,0xBF,0x1D,0xD0,0x8F,0x00,0x0F,0xC0,0x00,0x00,0x00,0x00,0x01,0xFD,0x2F,0x90,0xBC,0x00,0x0F,0xC0,0x00,0x00,0x00,0x00,0x08,0xF7,0xAF,0x40,0xCC,0x00,0x0F,0xC0,0x00,0x00,0x00,0x00,0x1F,0xF5,0xFC,0x5F,0xF9,0x06,0x8F,0xC0,0x00,0x00,0x00,0x00,0x3B,0xE5,0xF4,0x0D,0xD3,0x06,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x10,0x10,0x00,0x00,0x01,0x86,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x52,0x00,0x00,0x01,0x92,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFF,0x40,0x00,0x0A,0xFF,0xC4,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xF6,0x00,0x00,0x4C,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x0A,0xB1,0x09,0xB8,0x88,0x96,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xFF,0x80,0x03,0x00,0x00,0x00,0x00,0x1A,0x80,0x00,0x00,0x00,0x4F,0x80,0x2F,0x30,0x00,0x00,0x00,0x3F,0xFD,0x30,0x48,0x88,0x6F,0x90,0xBF,0xD0,0x00,0x00,0x00,0x01,0xDF,0x70,0x8F,0xFF,0x8F,0xF7,0xFB,0x10,0x00,0x00,0x00,0x00,0x13,0x00,0x24,0xAF,0x6F,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x04,0x00,0x00,0xDE,0x4F,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x0F,0xD0,0x02,0xFA,0x4F,0xBF,0xD1,0x00,0x00,0x00,0x00,0x00,0x5F,0xA0,0x0C,0xF3,0x4F,0x88,0xFC,0x10,0x00,0x00,0x00,0x00,0xBF,0x50,0xAF,0xB0,0x4F,0x80,0xCF,0xD4,0x00,0x00,0x00,0x02,0xFE,0x2B,0xFE,0x10,0x4F,0x80,0x1D,0xF6,0x00,0x00,0x00,0x0C,0xF9,0x1B,0xE3,0x29,0xBF,0x80,0x01,0xA0,0x00,0x00,0x00,0x3A,0xF3,0x00,0x10,0x0D,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x04,0x62,0x00,0x00,0x00,0x00,0x00,0x00,
							0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0xCC,0xCC,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFB,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xE1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xDF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xF5,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x2F,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xA0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xCF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x9C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x41,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xDF,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xF9,0x5D,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xA0,0x02,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x30,0x02,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x5D,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0B,0xFF,0xE3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x47,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6C,0x50,0x00,0x9F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xC0,0x01,0xEF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0D,0xFD,0xCE,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xAE,0xEC,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x14,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xBD,0xFF,0xA1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFC,0x8B,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xE0,0x00,0xCF,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x6F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x4F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x90,0x00,0x7F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xE1,0x00,0xEF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFE,0x8E,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x8B,0xFD,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xBC,0xFF,0xA1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFD,0x8C,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xE1,0x00,0xDF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x8F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x8F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x90,0x00,0x9F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xE1,0x01,0xEF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFE,0x9E,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xAB,0xFC,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x43,0x00,0x03,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xBE,0xFF,0xC4,0xEF,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFB,0x8E,0xFF,0xB8,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x4F,0xF0,0x05,0xFF,0x00,0x5F,0xB0,0x00,0x00,0x00,0x00,0x00,0x4F,0xC0,0x04,0xFC,0x00,0x4F,0xC0,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x04,0xFC,0x00,0x4F,0xC0,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x04,0xFC,0x00,0x4F,0xC0,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x04,0xFC,0x00,0x4F,0xC0,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x04,0xFC,0x00,0x4F,0xC0,0x00,0x00,0x00,0x00,0x00,0x3C,0x60,0x03,0xC9,0x00,0x3C,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_18_2[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x63,0x00,0x00,0x01,0xA4,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0x60,0x00,0x0B,0xFF,0xD6,0x00,0x00,0x00,0x00,0x00,0x01,0xAF,0xF8,0x00,0x00,0x6E,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x0A,0xB1,0x09,0xCC,0xCC,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x0C,0xFF,0xFF,0xA0,0x03,0x00,0x00,0x00,0x00,0x1B,0xB1,0x00,0x01,0x00,0x8F,0x80,0x2F,0x40,0x00,0x00,0x00,0x5F,0xFF,0x40,0x48,0x88,0xCF,0xA0,0xCF,0xE1,0x00,0x00,0x00,0x03,0xDF,0x70,0x8F,0xFF,0xDF,0xF9,0xFD,0x20,0x00,0x00,0x00,0x00,0x13,0x00,0x24,0xBF,0xCF,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x06,0x00,0x00,0xEF,0x8F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x2F,0xE1,0x04,0xFB,0x8F,0xCF,0xE1,0x00,0x00,0x00,0x00,0x00,0x6F,0xB0,0x0D,0xF4,0x8F,0x8A,0xFD,0x10,0x00,0x00,0x00,0x00,0xDF,0x60,0xAF,0xC0,0x8F,0x81,0xDF,0xF5,0x00,0x00,0x00,0x04,0xFF,0x4D,0xFF,0x20,0x8F,0x80,0x2F,0xF7,0x00,0x00,0x00,0x1D,0xFB,0x1A,0xF3,0x3C,0xEF,0x80,0x03,0xB0,0x00,0x00,0x00,0x3A,0xF5,0x00,0x20,0x0D,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x06,0x83,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x24,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x68,0x00,0x00,0x00,0x8F,0x80,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xB1,0x00,0x00,0x8F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFB,0x3C,0xC0,0x8F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xA0,0x4F,0xC0,0x8F,0x80,0x27,0x10,0x00,0x00,0x00,0x01,0x10,0x00,0x4F,0xC0,0x8F,0xCD,0xFF,0x00,0x00,0x00,0x00,0x1D,0xF5,0x00,0x4F,0xD9,0xEF,0xFF,0xFF,0x00,0x00,0x00,0x00,0x2B,0xFF,0xB5,0xBF,0xFF,0xFF,0xA0,0xCF,0x00,0x00,0x00,0x00,0x00,0x9F,0x4F,0xFF,0xE6,0x8F,0x80,0xCF,0x00,0x00,0x00,0x00,0x00,0x01,0x07,0x9F,0xC0,0x8F,0x80,0xCF,0x10,0x00,0x00,0x00,0x00,0x0A,0x40,0x4F,0xC0,0x8F,0xA4,0xEF,0x40,0x00,0x00,0x00,0x00,0x1F,0xF2,0x4F,0xC0,0x8F,0xBF,0xFF,0x00,0x00,0x00,0x00,0x00,0x6F,0xB0,0x4F,0xC0,0x8F,0x8A,0xA3,0x00,0x00,0x00,0x00,0x00,0xCF,0x60,0x4F,0xC0,0x9F,0x80,0x09,0x50,0x00,0x00,0x00,0x04,0xFF,0x10,0x4F,0xE0,0x34,0x30,0x0D,0xFA,0x00,0x00,0x00,0x1E,0xFB,0x00,0x0F,0xFF,0xFF,0xFF,0xFF,0xF6,0x00,0x00,0x00,0x03,0xA6,0x00,0x08,0xFF,0xFF,0xFF,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x81,0x00,0x5B,0x30,0x00,0xBB,0x30,0x00,0x00,0x00,0x00,0x0B,0xFD,0x10,0x5F,0xA0,0x00,0xFF,0x10,0x00,0x00,0x00,0x00,0x01,0xDF,0xF1,0x0D,0x80,0x16,0xFF,0xCC,0xC0,0x00,0x00,0x00,0x00,0x1E,0xBF,0xFF,0xFF,0x4C,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x00,0x00,0x6D,0xFE,0xCC,0x8F,0xA0,0x00,0x00,0x00,0x00,0x00,0x3D,0x70,0x04,0xF8,0x03,0xFF,0xD8,0x88,0x82,0x00,0x00,0x00,0x6F,0xFB,0x14,0xFE,0xCF,0xFD,0xCC,0xEF,0xF3,0x00,0x00,0x00,0x03,0xFC,0x24,0xFE,0xEF,0x41,0x03,0xFF,0x30,0x00,0x00,0x00,0x00,0x30,0x06,0xF4,0x8F,0x40,0x1F,0xF3,0x00,0x00,0x00,0x00,0x00,0x32,0x08,0xF4,0x8F,0xBC,0xCF,0xFC,0xD4,0x00,0x00,0x00,0x00,0x8F,0x6B,0xF2,0x8F,0x8F,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0xDF,0x3E,0xF0,0xAF,0x00,0x0F,0xC0,0x00,0x00,0x00,0x00,0x02,0xFE,0x4F,0xA0,0xCF,0x00,0x0F,0xC0,0x00,0x00,0x00,0x00,0x0A,0xF9,0xBF,0x60,0xDC,0x00,0x0F,0xC0,0x00,0x00,0x00,0x00,0x3F,0xF9,0xFE,0x4F,0xFB,0x08,0x8F,0xC0,0x00,0x00,0x00,0x00,0x4B,0xF5,0xF5,0x0E,0xE4,0x06,0xFF,0xA0,0x00,0x00,0x00,0x00,0x00,0x10,0x30,0x01,0x00,0x01,0xC7,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x63,0x00,0x00,0x01,0xA4,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0x60,0x00,0x0B,0xFF,0xD6,0x00,0x00,0x00,0x00,0x00,0x01,0xAF,0xF8,0x00,0x00,0x6E,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x0A,0xB1,0x09,0xCC,0xCC,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x0C,0xFF,0xFF,0xA0,0x03,0x00,0x00,0x00,0x00,0x1B,0xB1,0x00,0x01,0x00,0x8F,0x80,0x2F,0x40,0x00,0x00,0x00,0x5F,0xFF,0x40,0x48,0x88,0xCF,0xA0,0xCF,0xE1,0x00,0x00,0x00,0x03,0xDF,0x70,0x8F,0xFF,0xDF,0xF9,0xFD,0x20,0x00,0x00,0x00,0x00,0x13,0x00,0x24,0xBF,0xCF,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x06,0x00,0x00,0xEF,0x8F,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x2F,0xE1,0x04,0xFB,0x8F,0xCF,0xE1,0x00,0x00,0x00,0x00,0x00,0x6F,0xB0,0x0D,0xF4,0x8F,0x8A,0xFD,0x10,0x00,0x00,0x00,0x00,0xDF,0x60,0xAF,0xC0,0x8F,0x81,0xDF,0xF5,0x00,0x00,0x00,0x04,0xFF,0x4D,0xFF,0x20,0x8F,0x80,0x2F,0xF7,0x00,0x00,0x00,0x1D,0xFB,0x1A,0xF3,0x3C,0xEF,0x80,0x03,0xB0,0x00,0x00,0x00,0x3A,0xF5,0x00,0x20,0x0D,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x06,0x83,0x00,0x00,0x00,0x00,0x00,0x00,
							0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x24,0x44,0x44,0x44,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xFF,0xFF,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0A,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x5F,0xF2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xEF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xF1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xB0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xCF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xEF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xCC,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x42,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xEF,0xFF,0xC1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1F,0xFB,0x7D,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7F,0xD0,0x04,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x14,0x40,0x05,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x7E,0xF9,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFF,0xF5,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x48,0xFF,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xDF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x9C,0x60,0x00,0xCF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7F,0xE1,0x02,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1F,0xFE,0xCF,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xBF,0xFC,0x81,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x24,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xC0,0x32,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xEE,0xFF,0xC3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xFD,0x8C,0xFE,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xE1,0x00,0xDF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xC0,0x00,0x8F,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xC0,0x00,0x8F,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xC0,0x00,0x9F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xF1,0x01,0xEF,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xFE,0xAE,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xEC,0xFE,0x81,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x32,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xBE,0xFF,0xC2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFE,0x8E,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xE1,0x01,0xEF,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x90,0x00,0x9F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x8F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xC0,0x00,0xAF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF1,0x02,0xFF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xFE,0xCF,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xBC,0xFE,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x14,0x31,0x44,0x00,0x14,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xEF,0xFF,0xD5,0xFF,0xFC,0x10,0x00,0x00,0x00,0x00,0x00,0x4F,0xFB,0x9F,0xFF,0xB9,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x4F,0xF3,0x06,0xFF,0x10,0x6F,0xC0,0x00,0x00,0x00,0x00,0x00,0x4F,0xE0,0x04,0xFD,0x00,0x4F,0xC0,0x00,0x00,0x00,0x00,0x00,0x4F,0xC0,0x04,0xFC,0x00,0x4F,0xC0,0x00,0x00,0x00,0x00,0x00,0x4F,0xC0,0x04,0xFC,0x00,0x4F,0xC0,0x00,0x00,0x00,0x00,0x00,0x4F,0xC0,0x04,0xFC,0x00,0x4F,0xC0,0x00,0x00,0x00,0x00,0x00,0x4F,0xC0,0x04,0xFC,0x00,0x4F,0xC0,0x00,0x00,0x00,0x00,0x00,0x4F,0xC0,0x03,0xC9,0x00,0x3C,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_18_2_5[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x84,0x00,0x00,0x01,0xD6,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0x80,0x00,0x1C,0xFF,0xE7,0x10,0x00,0x00,0x00,0x00,0x01,0xDF,0xF9,0x00,0x01,0x8F,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x1D,0xB1,0x0A,0xCC,0xCD,0xF7,0x00,0x00,0x00,0x00,0x00,0x01,0x01,0x00,0x0C,0xFF,0xFF,0xC0,0x05,0x00,0x00,0x00,0x00,0x1D,0xC2,0x00,0x03,0x30,0x8F,0xC0,0x4F,0x60,0x00,0x00,0x00,0x6F,0xFF,0x70,0x48,0x88,0xCF,0xC0,0xCF,0xF1,0x00,0x00,0x00,0x03,0xFF,0x70,0x8F,0xFF,0xFF,0xFB,0xFE,0x40,0x00,0x00,0x00,0x00,0x33,0x00,0x48,0xEF,0xCF,0xFF,0x91,0x00,0x00,0x00,0x00,0x00,0x07,0x00,0x00,0xEF,0x9F,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x3F,0xE1,0x05,0xFD,0x8F,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x9F,0xD0,0x1E,0xF6,0x8F,0xCC,0xFE,0x30,0x00,0x00,0x00,0x00,0xEF,0x71,0xDF,0xE0,0x8F,0xC1,0xFF,0xF7,0x00,0x00,0x00,0x06,0xFF,0x7E,0xFF,0x30,0x8F,0xC0,0x3F,0xF8,0x00,0x00,0x00,0x1E,0xFD,0x1A,0xF6,0x3C,0xEF,0xC0,0x03,0xD0,0x00,0x00,0x00,0x4B,0xF7,0x00,0x30,0x0D,0xFF,0x90,0x00,0x10,0x00,0x00,0x00,0x00,0x22,0x00,0x00,0x06,0xA6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x34,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x7A,0x00,0x00,0x00,0x9F,0x80,0x00,0x00,0x00,0x00,0x00,0x07,0xFF,0xD1,0x00,0x00,0x8F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xFC,0x3C,0xC0,0x8F,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xA0,0x4F,0xF0,0x8F,0x80,0x39,0x30,0x00,0x00,0x00,0x01,0x30,0x00,0x4F,0xC0,0x8F,0xEE,0xFF,0x40,0x00,0x00,0x00,0x1D,0xF7,0x00,0x4F,0xEA,0xFF,0xFF,0xFF,0x40,0x00,0x00,0x00,0x2D,0xFF,0xC6,0xCF,0xFF,0xFF,0xA1,0xFF,0x40,0x00,0x00,0x00,0x00,0xAF,0x4F,0xFF,0xE6,0x9F,0x80,0xFF,0x40,0x00,0x00,0x00,0x00,0x02,0x09,0xAF,0xC0,0x8F,0x80,0xFF,0x40,0x00,0x00,0x00,0x00,0x0B,0x40,0x4F,0xC0,0x8F,0xA5,0xFF,0x40,0x00,0x00,0x00,0x00,0x2F,0xF3,0x4F,0xC0,0x8F,0xCF,0xFF,0x20,0x00,0x00,0x00,0x00,0x7F,0xE0,0x4F,0xC0,0xAF,0x9B,0xB5,0x00,0x00,0x00,0x00,0x00,0xEF,0x90,0x4F,0xC0,0xCF,0xC0,0x0A,0x60,0x00,0x00,0x00,0x06,0xFF,0x30,0x4F,0xF1,0x34,0x30,0x0E,0xFC,0x00,0x00,0x00,0x3F,0xFE,0x00,0x2F,0xFF,0xFF,0xFF,0xFF,0xF7,0x00,0x00,0x00,0x03,0xA9,0x00,0x0A,0xFF,0xFF,0xFF,0xFF,0xD1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x00,0x00,0x01,0xA1,0x00,0x6B,0x40,0x00,0xDC,0x50,0x00,0x00,0x00,0x00,0x0C,0xFE,0x30,0x6F,0xB0,0x01,0xFF,0x10,0x00,0x00,0x00,0x00,0x03,0xFF,0xF2,0x1D,0x93,0x17,0xFF,0xCC,0xC0,0x00,0x00,0x00,0x00,0x3E,0xBF,0xFF,0xFF,0x4E,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x01,0x01,0x6D,0xFE,0xCC,0xAF,0xA0,0x00,0x00,0x00,0x00,0x00,0x3F,0x90,0x04,0xF8,0x03,0xFF,0xDC,0xCC,0xC3,0x00,0x00,0x00,0x6F,0xFD,0x24,0xFE,0xCF,0xFF,0xCC,0xEF,0xF4,0x00,0x00,0x00,0x06,0xFC,0x16,0xFF,0xFF,0x71,0x06,0xFF,0x30,0x00,0x00,0x00,0x00,0x40,0x08,0xF8,0x8F,0x40,0x4F,0xF4,0x00,0x00,0x00,0x00,0x00,0x52,0x09,0xF4,0x8F,0xCE,0xCF,0xFC,0xF4,0x00,0x00,0x00,0x00,0xAF,0x8C,0xF3,0xAF,0xBF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0xEF,0x4F,0xF0,0xCF,0x00,0x0F,0xF0,0x00,0x00,0x00,0x00,0x04,0xFF,0x6F,0xB0,0xCF,0x00,0x0F,0xF0,0x00,0x00,0x00,0x00,0x0A,0xFA,0xCF,0x91,0xEE,0x00,0x0F,0xF0,0x00,0x00,0x00,0x00,0x4F,0xFC,0xFF,0x5F,0xFC,0x1A,0x9F,0xF0,0x00,0x00,0x00,0x00,0x4B,0xF6,0xF7,0x0E,0xF6,0x06,0xFF,0xB0,0x00,0x00,0x00,0x00,0x00,0x10,0x30,0x03,0x00,0x01,0xCA,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x84,0x00,0x00,0x01,0xD6,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFF,0x80,0x00,0x1C,0xFF,0xE7,0x10,0x00,0x00,0x00,0x00,0x01,0xDF,0xF9,0x00,0x01,0x8F,0xFF,0x60,0x00,0x00,0x00,0x00,0x00,0x1D,0xB1,0x0A,0xCC,0xCD,0xF7,0x00,0x00,0x00,0x00,0x00,0x01,0x01,0x00,0x0C,0xFF,0xFF,0xC0,0x05,0x00,0x00,0x00,0x00,0x1D,0xC2,0x00,0x03,0x30,0x8F,0xC0,0x4F,0x60,0x00,0x00,0x00,0x6F,0xFF,0x70,0x48,0x88,0xCF,0xC0,0xCF,0xF1,0x00,0x00,0x00,0x03,0xFF,0x70,0x8F,0xFF,0xFF,0xFB,0xFE,0x40,0x00,0x00,0x00,0x00,0x33,0x00,0x48,0xEF,0xCF,0xFF,0x91,0x00,0x00,0x00,0x00,0x00,0x07,0x00,0x00,0xEF,0x9F,0xFF,0x50,0x00,0x00,0x00,0x00,0x00,0x3F,0xE1,0x05,0xFD,0x8F,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0x9F,0xD0,0x1E,0xF6,0x8F,0xCC,0xFE,0x30,0x00,0x00,0x00,0x00,0xEF,0x71,0xDF,0xE0,0x8F,0xC1,0xFF,0xF7,0x00,0x00,0x00,0x06,0xFF,0x7E,0xFF,0x30,0x8F,0xC0,0x3F,0xF8,0x00,0x00,0x00,0x1E,0xFD,0x1A,0xF6,0x3C,0xEF,0xC0,0x03,0xD0,0x00,0x00,0x00,0x4B,0xF7,0x00,0x30,0x0D,0xFF,0x90,0x00,0x10,0x00,0x00,0x00,0x00,0x22,0x00,0x00,0x06,0xA6,0x00,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_18_3[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x96,0x00,0x00,0x01,0xD7,0x10,0x00,0x00,0x00,0x00,0x00,0x0A,0xFF,0xA1,0x00,0x1D,0xFF,0xF8,0x10,0x00,0x00,0x00,0x00,0x03,0xDF,0xFB,0x00,0x02,0xAF,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x1D,0xB1,0x0F,0xFF,0xFF,0xF7,0x00,0x00,0x00,0x00,0x00,0x01,0x02,0x00,0x0F,0xFF,0xFF,0xC0,0x06,0x00,0x00,0x00,0x00,0x1D,0xD3,0x00,0x04,0x44,0xAF,0xC0,0x4F,0x60,0x00,0x00,0x00,0x8F,0xFF,0x80,0x6C,0xCC,0xEF,0xD0,0xDF,0xF4,0x00,0x00,0x00,0x06,0xFF,0x71,0x8F,0xFF,0xFF,0xFC,0xFF,0x70,0x00,0x00,0x00,0x00,0x35,0x00,0x48,0xEF,0xEF,0xFF,0xB2,0x00,0x00,0x00,0x00,0x00,0x17,0x00,0x00,0xFF,0xAF,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x5F,0xE2,0x06,0xFE,0x8F,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0xAF,0xE0,0x1F,0xF8,0x8F,0xCD,0xFF,0x40,0x00,0x00,0x00,0x00,0xFF,0x92,0xDF,0xF1,0x8F,0xC3,0xFF,0xF8,0x00,0x00,0x00,0x07,0xFF,0x9F,0xFF,0x50,0x8F,0xC0,0x4F,0xF9,0x00,0x00,0x00,0x3F,0xFE,0x1A,0xF6,0x4D,0xFF,0xC0,0x06,0xD0,0x00,0x00,0x00,0x4B,0xF9,0x00,0x40,0x0D,0xFF,0xB0,0x00,0x10,0x00,0x00,0x00,0x00,0x22,0x00,0x00,0x06,0xC7,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x34,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0xAB,0x10,0x00,0x00,0xCF,0xC0,0x00,0x00,0x00,0x00,0x00,0x07,0xFF,0xE3,0x00,0x00,0xCF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xFC,0x5C,0xC2,0xCF,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x0A,0xA0,0x4F,0xF0,0xCF,0xC0,0x5A,0x40,0x00,0x00,0x00,0x01,0x41,0x00,0x4F,0xF0,0xCF,0xFF,0xFF,0x40,0x00,0x00,0x00,0x2D,0xF9,0x10,0x4F,0xFB,0xFF,0xFF,0xFF,0x40,0x00,0x00,0x00,0x3D,0xFF,0xD8,0xDF,0xFF,0xFF,0xD2,0xFF,0x40,0x00,0x00,0x00,0x01,0xDF,0x4F,0xFF,0xF7,0xDF,0xC0,0xFF,0x40,0x00,0x00,0x00,0x00,0x13,0x0A,0xBF,0xF0,0xCF,0xC0,0xFF,0x40,0x00,0x00,0x00,0x00,0x0C,0x40,0x4F,0xF0,0xCF,0xD7,0xFF,0x40,0x00,0x00,0x00,0x00,0x4F,0xF5,0x4F,0xF0,0xCF,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x9F,0xF0,0x4F,0xF0,0xCF,0xCD,0xD6,0x00,0x00,0x00,0x00,0x00,0xFF,0xA0,0x4F,0xF0,0xCF,0xC0,0x0B,0x61,0x00,0x00,0x00,0x07,0xFF,0x50,0x4F,0xF2,0x44,0x30,0x1F,0xFC,0x00,0x00,0x00,0x4F,0xFF,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xF9,0x00,0x00,0x00,0x03,0xAA,0x00,0x0D,0xFF,0xFF,0xFF,0xFF,0xE1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x44,0x44,0x44,0x43,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x00,0x00,0x01,0xA3,0x00,0x6B,0x60,0x00,0xED,0x50,0x00,0x00,0x00,0x00,0x1D,0xFF,0x30,0x7F,0xD0,0x03,0xFF,0x20,0x00,0x00,0x00,0x00,0x03,0xFF,0xF5,0x2E,0xB4,0x18,0xFF,0xCC,0xF0,0x00,0x00,0x00,0x00,0x4F,0xBF,0xFF,0xFF,0x5F,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x01,0x01,0x8F,0xFE,0xCF,0xDF,0xC0,0x00,0x10,0x00,0x00,0x00,0x3F,0xB1,0x08,0xF8,0x06,0xFF,0xEC,0xCC,0xC6,0x00,0x00,0x00,0xAF,0xFE,0x38,0xFF,0xFF,0xFF,0xEC,0xFF,0xF8,0x00,0x00,0x00,0x06,0xFC,0x18,0xFF,0xFF,0x81,0x06,0xFF,0x40,0x00,0x00,0x00,0x00,0x40,0x08,0xF8,0x8F,0x70,0x4F,0xF6,0x00,0x00,0x00,0x00,0x00,0x52,0x0B,0xF7,0xAF,0xCF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0xBF,0x8D,0xF4,0xCF,0xCF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x00,0xFF,0x8F,0xF1,0xCF,0x50,0x4F,0xF0,0x11,0x00,0x00,0x00,0x05,0xFF,0x8F,0xD0,0xDF,0x00,0x4F,0xF0,0x00,0x00,0x00,0x00,0x0C,0xFB,0xEF,0xA4,0xFF,0x00,0x4F,0xF0,0x00,0x00,0x00,0x00,0x6F,0xFF,0xFF,0x5F,0xFD,0x1B,0xAF,0xF0,0x00,0x00,0x00,0x00,0x5C,0xF7,0xF8,0x0E,0xF7,0x06,0xFF,0xE0,0x00,0x00,0x00,0x00,0x00,0x20,0x30,0x04,0x20,0x01,0xCB,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x96,0x00,0x00,0x01,0xD7,0x10,0x00,0x00,0x00,0x00,0x00,0x0A,0xFF,0xA1,0x00,0x1D,0xFF,0xF8,0x10,0x00,0x00,0x00,0x00,0x03,0xDF,0xFB,0x00,0x02,0xAF,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x1D,0xB1,0x0F,0xFF,0xFF,0xF7,0x00,0x00,0x00,0x00,0x00,0x01,0x02,0x00,0x0F,0xFF,0xFF,0xC0,0x06,0x00,0x00,0x00,0x00,0x1D,0xD3,0x00,0x04,0x44,0xAF,0xC0,0x4F,0x60,0x00,0x00,0x00,0x8F,0xFF,0x80,0x6C,0xCC,0xEF,0xD0,0xDF,0xF4,0x00,0x00,0x00,0x06,0xFF,0x71,0x8F,0xFF,0xFF,0xFC,0xFF,0x70,0x00,0x00,0x00,0x00,0x35,0x00,0x48,0xEF,0xEF,0xFF,0xB2,0x00,0x00,0x00,0x00,0x00,0x17,0x00,0x00,0xFF,0xAF,0xFF,0x70,0x00,0x00,0x00,0x00,0x00,0x5F,0xE2,0x06,0xFE,0x8F,0xFF,0xF3,0x00,0x00,0x00,0x00,0x00,0xAF,0xE0,0x1F,0xF8,0x8F,0xCD,0xFF,0x40,0x00,0x00,0x00,0x00,0xFF,0x92,0xDF,0xF1,0x8F,0xC3,0xFF,0xF8,0x00,0x00,0x00,0x07,0xFF,0x9F,0xFF,0x50,0x8F,0xC0,0x4F,0xF9,0x00,0x00,0x00,0x3F,0xFE,0x1A,0xF6,0x4D,0xFF,0xC0,0x06,0xD0,0x00,0x00,0x00,0x4B,0xF9,0x00,0x40,0x0D,0xFF,0xB0,0x00,0x10,0x00,0x00,0x00,0x00,0x22,0x00,0x00,0x06,0xC7,0x10,0x00,0x00,0x00,0x00,0x00};

const uint8_t t_20_1[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x11,0x00,0x00,0x00,0x06,0x10,0x00,0x00,0x00,0x00,0x00,0x01,0xDF,0x30,0x00,0x00,0xAF,0xF8,0x10,0x00,0x00,0x00,0x00,0x00,0xAF,0xF6,0x00,0x00,0x16,0xEF,0xFA,0x10,0x00,0x00,0x00,0x00,0x06,0xFD,0x10,0x00,0x00,0x08,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x41,0x00,0xCF,0xFF,0xFC,0x10,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x68,0x88,0xFC,0x00,0x06,0x00,0x00,0x00,0x1D,0xD3,0x00,0x00,0x00,0x00,0xFC,0x00,0x8F,0x30,0x00,0x00,0x0A,0xFF,0x80,0x06,0x88,0x83,0xFE,0x02,0xFF,0x60,0x00,0x00,0x00,0x6F,0xC1,0x0C,0xFF,0xF4,0xFF,0x7D,0xF4,0x00,0x00,0x00,0x00,0x04,0x00,0x03,0x4A,0xF3,0xFF,0xFC,0x10,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x0B,0xF0,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x07,0xE3,0x00,0x1F,0xA0,0xFC,0xCF,0x30,0x00,0x00,0x00,0x00,0x0D,0xF2,0x00,0x8F,0x40,0xFC,0x3F,0xD1,0x00,0x00,0x00,0x00,0x2F,0xD0,0x03,0xFC,0x00,0xFC,0x07,0xFD,0x30,0x00,0x00,0x00,0x8F,0x70,0x4F,0xF3,0x00,0xFC,0x00,0xAF,0xF6,0x00,0x00,0x01,0xFF,0x19,0xFF,0x60,0x00,0xFC,0x00,0x0A,0xF1,0x00,0x00,0x0B,0xFB,0x01,0xC6,0x01,0xCD,0xFC,0x00,0x00,0x40,0x00,0x00,0x16,0xE6,0x00,0x00,0x00,0xBF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x24,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x15,0x00,0x00,0x00,0x03,0xC9,0x00,0x00,0x00,0x00,0x00,0x01,0xCF,0x90,0x00,0x00,0x00,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xFC,0x10,0x00,0x00,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFB,0x24,0xFB,0x00,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x04,0xF8,0x00,0xFC,0x03,0x89,0x00,0x00,0x00,0x01,0x50,0x00,0x04,0xF8,0x00,0xFF,0xEF,0xFC,0x00,0x00,0x00,0x0C,0xF9,0x10,0x04,0xFB,0xAE,0xFF,0xD7,0xFC,0x00,0x00,0x00,0x03,0xEF,0xE3,0x5B,0xFF,0xFD,0xFC,0x00,0xFC,0x00,0x00,0x00,0x00,0x1D,0xA5,0xFF,0xFB,0x20,0xFC,0x00,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x85,0xF8,0x00,0xFC,0x00,0xFC,0x00,0x00,0x00,0x00,0x02,0x50,0x04,0xF8,0x00,0xFC,0x01,0xFC,0x00,0x00,0x00,0x00,0x06,0xF9,0x04,0xF8,0x00,0xFD,0xAF,0xFA,0x00,0x00,0x00,0x00,0x0B,0xF2,0x04,0xF8,0x00,0xFC,0x6F,0xA1,0x00,0x00,0x00,0x00,0x2F,0xD0,0x04,0xF8,0x04,0xFC,0x00,0x01,0x00,0x00,0x00,0x00,0x8F,0x70,0x04,0xF8,0x02,0x86,0x00,0x0C,0xA3,0x00,0x00,0x01,0xFF,0x20,0x03,0xFC,0x10,0x00,0x00,0x1F,0xF3,0x00,0x00,0x0B,0xFD,0x00,0x00,0xFF,0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0x00,0x00,0x55,0x00,0x00,0x3B,0xCC,0xCC,0xCC,0xC9,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x30,0x00,0x05,0x90,0x00,0x01,0xA5,0x00,0x00,0x00,0x00,0x05,0xFA,0x10,0x07,0xF4,0x00,0x06,0xF7,0x00,0x00,0x00,0x00,0x01,0xDF,0xD1,0x02,0xFA,0x00,0x0B,0xF5,0x44,0x40,0x00,0x00,0x00,0x1D,0xFA,0x44,0x64,0x64,0x2F,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x01,0x3F,0xFF,0xFF,0xF8,0x9F,0x54,0x44,0x40,0x00,0x00,0x02,0x00,0x04,0xAF,0x44,0x45,0xFA,0x00,0x00,0x00,0x00,0x00,0x3F,0xB1,0x00,0x8F,0x00,0x1E,0xFD,0xCC,0xCC,0x90,0x00,0x00,0x1A,0xFE,0x30,0x8F,0xCC,0xDA,0x88,0x88,0xEF,0x90,0x00,0x00,0x00,0xAF,0x40,0x8F,0xCD,0xF4,0x00,0x06,0xFA,0x00,0x00,0x00,0x00,0x02,0x00,0x8F,0x04,0xF4,0x00,0x5F,0xC0,0x00,0x00,0x00,0x00,0x01,0x00,0xBF,0x06,0xF2,0x88,0xCF,0xA8,0x82,0x00,0x00,0x00,0x0F,0xA0,0xDC,0x08,0xF4,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x3F,0x90,0xF9,0x08,0xF1,0x00,0x4F,0x40,0x11,0x00,0x00,0x00,0x9F,0x35,0xF6,0x08,0xD0,0x00,0x4F,0x40,0x00,0x00,0x00,0x00,0xFE,0x0A,0xF1,0x0C,0xC0,0x00,0x4F,0x40,0x00,0x00,0x00,0x06,0xFA,0x2F,0xA3,0x2E,0xB0,0x00,0x4F,0x40,0x00,0x00,0x00,0x1E,0xF5,0xDF,0x36,0xFF,0x80,0x59,0xDF,0x40,0x00,0x00,0x00,0x17,0xD1,0xA9,0x00,0xC8,0x10,0x0F,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x06,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x11,0x00,0x00,0x00,0x06,0x10,0x00,0x00,0x00,0x00,0x00,0x01,0xDF,0x30,0x00,0x00,0xAF,0xF8,0x10,0x00,0x00,0x00,0x00,0x00,0xAF,0xF6,0x00,0x00,0x16,0xEF,0xFA,0x10,0x00,0x00,0x00,0x00,0x06,0xFD,0x10,0x00,0x00,0x08,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x41,0x00,0xCF,0xFF,0xFC,0x10,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x68,0x88,0xFC,0x00,0x06,0x00,0x00,0x00,0x1D,0xD3,0x00,0x00,0x00,0x00,0xFC,0x00,0x8F,0x30,0x00,0x00,0x0A,0xFF,0x80,0x06,0x88,0x83,0xFE,0x02,0xFF,0x60,0x00,0x00,0x00,0x6F,0xC1,0x0C,0xFF,0xF4,0xFF,0x7D,0xF4,0x00,0x00,0x00,0x00,0x04,0x00,0x03,0x4A,0xF3,0xFF,0xFC,0x10,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x0B,0xF0,0xFF,0xF8,0x00,0x00,0x00,0x00,0x00,0x07,0xE3,0x00,0x1F,0xA0,0xFC,0xCF,0x30,0x00,0x00,0x00,0x00,0x0D,0xF2,0x00,0x8F,0x40,0xFC,0x3F,0xD1,0x00,0x00,0x00,0x00,0x2F,0xD0,0x03,0xFC,0x00,0xFC,0x07,0xFD,0x30,0x00,0x00,0x00,0x8F,0x70,0x4F,0xF3,0x00,0xFC,0x00,0xAF,0xF6,0x00,0x00,0x01,0xFF,0x19,0xFF,0x60,0x00,0xFC,0x00,0x0A,0xF1,0x00,0x00,0x0B,0xFB,0x01,0xC6,0x01,0xCD,0xFC,0x00,0x00,0x40,0x00,0x00,0x16,0xE6,0x00,0x00,0x00,0xBF,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x24,0x00,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_20_1_5[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x13,0x00,0x00,0x00,0x06,0x20,0x00,0x00,0x00,0x00,0x00,0x03,0xDF,0x50,0x00,0x00,0xAF,0xFA,0x20,0x00,0x00,0x00,0x00,0x01,0xAF,0xF9,0x00,0x00,0x28,0xFF,0xFA,0x10,0x00,0x00,0x00,0x00,0x0A,0xFD,0x10,0x42,0x00,0x18,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x71,0x00,0xFF,0xFF,0xFF,0x10,0x00,0x00,0x00,0x00,0x01,0x10,0x00,0x00,0xCA,0x8A,0xFD,0x00,0x16,0x00,0x00,0x00,0x1D,0xF5,0x00,0x00,0x00,0x04,0xFC,0x00,0x8F,0x50,0x00,0x00,0x2B,0xFF,0x91,0x06,0x88,0x88,0xFF,0x13,0xFF,0xA0,0x00,0x00,0x00,0x8F,0xC2,0x0C,0xFF,0xFA,0xFF,0x7D,0xF6,0x00,0x00,0x00,0x00,0x04,0x00,0x03,0x4A,0xF8,0xFF,0xFD,0x30,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x0C,0xF4,0xFF,0xF9,0x00,0x00,0x00,0x00,0x00,0x09,0xE4,0x00,0x2F,0xB4,0xFC,0xEF,0x40,0x00,0x00,0x00,0x00,0x0E,0xF3,0x00,0xAF,0x64,0xFC,0x4F,0xF3,0x00,0x00,0x00,0x00,0x3F,0xE0,0x06,0xFE,0x04,0xFC,0x09,0xFF,0x40,0x00,0x00,0x00,0xAF,0x90,0x6F,0xF4,0x04,0xFC,0x00,0xBF,0xF7,0x00,0x00,0x02,0xFF,0x39,0xFF,0x60,0x04,0xFC,0x00,0x1D,0xF1,0x00,0x00,0x0C,0xFD,0x01,0xD6,0x03,0xEE,0xFC,0x00,0x01,0x50,0x00,0x00,0x17,0xE7,0x00,0x00,0x00,0xBF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x45,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x16,0x00,0x00,0x00,0x04,0xFC,0x00,0x00,0x00,0x00,0x00,0x01,0xDF,0xA1,0x00,0x00,0x04,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFD,0x21,0x43,0x04,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xFB,0x14,0xFC,0x04,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x04,0xFC,0x04,0xFC,0x05,0x9A,0x00,0x00,0x00,0x01,0x60,0x00,0x04,0xFC,0x04,0xFF,0xFF,0xFC,0x00,0x00,0x00,0x1D,0xFC,0x10,0x04,0xFE,0xBF,0xFF,0xDA,0xFC,0x00,0x00,0x00,0x04,0xFF,0xF6,0x6C,0xFF,0xFE,0xFC,0x04,0xFC,0x00,0x00,0x00,0x00,0x2D,0xA5,0xFF,0xFD,0x24,0xFC,0x04,0xFC,0x00,0x00,0x00,0x00,0x01,0x00,0x86,0xFC,0x04,0xFC,0x04,0xFC,0x00,0x00,0x00,0x00,0x03,0x40,0x04,0xFC,0x04,0xFC,0x04,0xFC,0x00,0x00,0x00,0x00,0x08,0xFA,0x04,0xFC,0x04,0xFD,0xBF,0xFB,0x00,0x00,0x00,0x00,0x0D,0xF5,0x04,0xFC,0x04,0xFC,0x6F,0xC3,0x00,0x00,0x00,0x00,0x2F,0xF0,0x04,0xFC,0x04,0xFC,0x10,0x02,0x00,0x00,0x00,0x00,0xAF,0x90,0x04,0xFC,0x02,0x87,0x00,0x0F,0xA3,0x00,0x00,0x03,0xFF,0x30,0x04,0xFE,0x34,0x44,0x44,0x5F,0xF5,0x00,0x00,0x0B,0xFE,0x00,0x01,0xFF,0xFF,0xFF,0xFF,0xFF,0xE0,0x00,0x00,0x00,0x56,0x00,0x00,0x5C,0xCC,0xCC,0xCC,0xCB,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x05,0x90,0x00,0x03,0xB6,0x00,0x00,0x00,0x00,0x06,0xFD,0x10,0x09,0xF6,0x00,0x07,0xF8,0x00,0x00,0x00,0x00,0x01,0xDF,0xD2,0x03,0xFB,0x00,0x0D,0xF6,0x44,0x40,0x00,0x00,0x00,0x1D,0xFC,0x88,0xB8,0x84,0x2F,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x03,0x2F,0xFF,0xFF,0xF8,0xBF,0x54,0x44,0x80,0x00,0x00,0x02,0x00,0x04,0xAF,0x74,0x47,0xFA,0x00,0x00,0x00,0x00,0x00,0x3F,0xC2,0x00,0x8F,0x40,0x3F,0xFF,0xCC,0xCC,0xC0,0x00,0x00,0x1D,0xFF,0x40,0x8F,0xDC,0xCC,0x88,0x88,0xFF,0xC0,0x00,0x00,0x01,0xAF,0x40,0x8F,0xCD,0xF4,0x00,0x09,0xFA,0x00,0x00,0x00,0x00,0x02,0x00,0xAF,0x06,0xF4,0x00,0x5F,0xD0,0x00,0x00,0x00,0x00,0x03,0x00,0xCF,0x08,0xF7,0x88,0xCF,0xC8,0x93,0x00,0x00,0x00,0x1F,0xA0,0xED,0x08,0xF5,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x5F,0xA2,0xFB,0x08,0xF1,0x44,0xAF,0x74,0x41,0x00,0x00,0x00,0xAF,0x56,0xF7,0x0B,0xF0,0x00,0x8F,0x40,0x00,0x00,0x00,0x01,0xFF,0x0C,0xF2,0x0C,0xD0,0x00,0x8F,0x40,0x00,0x00,0x00,0x08,0xFB,0x4F,0xC4,0x4E,0xC0,0x00,0x8F,0x40,0x00,0x00,0x00,0x2F,0xF7,0xEF,0x46,0xFF,0x90,0x5C,0xEF,0x40,0x00,0x00,0x00,0x27,0xE2,0xAB,0x00,0xEA,0x10,0x0F,0xFF,0x10,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x06,0x71,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x13,0x00,0x00,0x00,0x06,0x20,0x00,0x00,0x00,0x00,0x00,0x03,0xDF,0x50,0x00,0x00,0xAF,0xFA,0x20,0x00,0x00,0x00,0x00,0x01,0xAF,0xF9,0x00,0x00,0x28,0xFF,0xFA,0x10,0x00,0x00,0x00,0x00,0x0A,0xFD,0x10,0x42,0x00,0x18,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x71,0x00,0xFF,0xFF,0xFF,0x10,0x00,0x00,0x00,0x00,0x01,0x10,0x00,0x00,0xCA,0x8A,0xFD,0x00,0x16,0x00,0x00,0x00,0x1D,0xF5,0x00,0x00,0x00,0x04,0xFC,0x00,0x8F,0x50,0x00,0x00,0x2B,0xFF,0x91,0x06,0x88,0x88,0xFF,0x13,0xFF,0xA0,0x00,0x00,0x00,0x8F,0xC2,0x0C,0xFF,0xFA,0xFF,0x7D,0xF6,0x00,0x00,0x00,0x00,0x04,0x00,0x03,0x4A,0xF8,0xFF,0xFD,0x30,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x0C,0xF4,0xFF,0xF9,0x00,0x00,0x00,0x00,0x00,0x09,0xE4,0x00,0x2F,0xB4,0xFC,0xEF,0x40,0x00,0x00,0x00,0x00,0x0E,0xF3,0x00,0xAF,0x64,0xFC,0x4F,0xF3,0x00,0x00,0x00,0x00,0x3F,0xE0,0x06,0xFE,0x04,0xFC,0x09,0xFF,0x40,0x00,0x00,0x00,0xAF,0x90,0x6F,0xF4,0x04,0xFC,0x00,0xBF,0xF7,0x00,0x00,0x02,0xFF,0x39,0xFF,0x60,0x04,0xFC,0x00,0x1D,0xF1,0x00,0x00,0x0C,0xFD,0x01,0xD6,0x03,0xEE,0xFC,0x00,0x01,0x50,0x00,0x00,0x17,0xE7,0x00,0x00,0x00,0xBF,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x45,0x10,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_20_2[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x13,0x00,0x00,0x00,0x08,0x20,0x00,0x00,0x00,0x00,0x00,0x03,0xEF,0x70,0x00,0x00,0xAF,0xFC,0x40,0x00,0x00,0x00,0x00,0x01,0xDF,0xFA,0x10,0x00,0x2A,0xFF,0xFC,0x20,0x00,0x00,0x00,0x00,0x1A,0xFD,0x20,0x44,0x44,0x6E,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x81,0x00,0xFF,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x01,0x30,0x00,0x00,0xCC,0xCD,0xFF,0x00,0x27,0x00,0x00,0x00,0x2D,0xF7,0x00,0x00,0x00,0x04,0xFF,0x00,0xAF,0x60,0x00,0x00,0x2D,0xFF,0xC1,0x06,0x88,0x88,0xFF,0x14,0xFF,0xD0,0x00,0x00,0x00,0xAF,0xC2,0x0C,0xFF,0xFC,0xFF,0x9F,0xF8,0x00,0x00,0x00,0x00,0x06,0x00,0x03,0x4C,0xF9,0xFF,0xFE,0x40,0x00,0x00,0x00,0x00,0x03,0x00,0x00,0x0D,0xF6,0xFF,0xFB,0x00,0x00,0x00,0x00,0x00,0x0B,0xE5,0x00,0x3F,0xD4,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x0F,0xF5,0x00,0xCF,0x74,0xFF,0x5F,0xF3,0x00,0x00,0x00,0x00,0x5F,0xF0,0x07,0xFF,0x14,0xFF,0x0A,0xFF,0x60,0x00,0x00,0x00,0xCF,0xA0,0x8F,0xF5,0x04,0xFF,0x01,0xDF,0xF9,0x00,0x00,0x04,0xFF,0x5A,0xFF,0xA0,0x04,0xFF,0x00,0x1D,0xF2,0x00,0x00,0x1D,0xFF,0x01,0xDA,0x03,0xFF,0xFF,0x00,0x01,0x60,0x00,0x00,0x27,0xEA,0x00,0x00,0x00,0xBF,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x47,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x00,0x00,0x00,0x04,0xFE,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xD1,0x00,0x00,0x04,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xFF,0x32,0x44,0x04,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0xFB,0x16,0xFD,0x04,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x04,0xFC,0x04,0xFC,0x16,0xBC,0x00,0x00,0x00,0x01,0x80,0x00,0x04,0xFC,0x05,0xFF,0xFF,0xFC,0x00,0x00,0x00,0x2D,0xFD,0x30,0x04,0xFE,0xDF,0xFF,0xEB,0xFC,0x00,0x00,0x00,0x06,0xFF,0xF7,0x8D,0xFF,0xFF,0xFC,0x04,0xFC,0x00,0x00,0x00,0x00,0x3F,0xA5,0xFF,0xFE,0x34,0xFC,0x04,0xFC,0x00,0x00,0x00,0x00,0x01,0x01,0xA8,0xFC,0x04,0xFC,0x04,0xFC,0x00,0x00,0x00,0x00,0x04,0x40,0x04,0xFC,0x04,0xFC,0x05,0xFF,0x00,0x00,0x00,0x00,0x0A,0xFA,0x04,0xFC,0x04,0xFD,0xEF,0xFD,0x00,0x00,0x00,0x00,0x0E,0xF6,0x04,0xFC,0x04,0xFC,0x6F,0xE3,0x00,0x00,0x00,0x00,0x4F,0xF1,0x04,0xFC,0x06,0xFF,0x12,0x03,0x00,0x00,0x00,0x00,0xCF,0xB0,0x04,0xFC,0x06,0xCC,0x00,0x0F,0xB5,0x00,0x00,0x04,0xFF,0x60,0x04,0xFF,0x54,0x44,0x44,0x6F,0xF7,0x00,0x00,0x1D,0xFF,0x10,0x02,0xFF,0xFF,0xFF,0xFF,0xFF,0xF1,0x00,0x00,0x00,0x58,0x00,0x00,0x7C,0xCC,0xCC,0xCC,0xCC,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x51,0x00,0x06,0xA1,0x00,0x04,0xB6,0x10,0x00,0x00,0x00,0x06,0xFD,0x20,0x0A,0xF7,0x00,0x09,0xFA,0x00,0x00,0x00,0x00,0x03,0xFF,0xF3,0x05,0xFD,0x00,0x0E,0xF6,0x44,0x50,0x00,0x00,0x00,0x3F,0xFC,0x88,0xB8,0x86,0x4F,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x03,0x3F,0xFF,0xFF,0xF8,0xCF,0x98,0x88,0x80,0x00,0x00,0x03,0x10,0x05,0xAF,0x74,0x4B,0xFC,0x00,0x00,0x00,0x00,0x00,0x4F,0xD3,0x00,0x8F,0x40,0x3F,0xFF,0xFF,0xFF,0xF0,0x00,0x00,0x3D,0xFF,0x60,0x8F,0xFF,0xFC,0xC9,0x88,0xFF,0xE0,0x00,0x00,0x01,0xDF,0x50,0xAF,0xDE,0xF8,0x00,0x0A,0xFA,0x00,0x00,0x00,0x00,0x13,0x00,0xCF,0x28,0xF4,0x00,0x8F,0xE1,0x00,0x00,0x00,0x00,0x03,0x00,0xCF,0x08,0xF7,0xB8,0xCF,0xC8,0xC3,0x00,0x00,0x00,0x2F,0xB0,0xFF,0x08,0xF8,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x6F,0xB3,0xFC,0x0B,0xF2,0x44,0xAF,0xA4,0x41,0x00,0x00,0x00,0xBF,0x67,0xF8,0x0C,0xF0,0x00,0x8F,0x80,0x00,0x00,0x00,0x02,0xFF,0x2E,0xF3,0x0C,0xF0,0x00,0x8F,0x80,0x00,0x00,0x00,0x09,0xFD,0x6F,0xE5,0x5F,0xC0,0x00,0x8F,0x80,0x00,0x00,0x00,0x3F,0xF9,0xFF,0x66,0xFF,0xB0,0x7C,0xFF,0x70,0x00,0x00,0x00,0x37,0xE5,0xAC,0x00,0xFB,0x30,0x1F,0xFF,0x20,0x00,0x00,0x00,0x00,0x01,0x01,0x00,0x00,0x00,0x08,0x82,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x13,0x00,0x00,0x00,0x08,0x20,0x00,0x00,0x00,0x00,0x00,0x03,0xEF,0x70,0x00,0x00,0xAF,0xFC,0x40,0x00,0x00,0x00,0x00,0x01,0xDF,0xFA,0x10,0x00,0x2A,0xFF,0xFC,0x20,0x00,0x00,0x00,0x00,0x1A,0xFD,0x20,0x44,0x44,0x6E,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x81,0x00,0xFF,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x01,0x30,0x00,0x00,0xCC,0xCD,0xFF,0x00,0x27,0x00,0x00,0x00,0x2D,0xF7,0x00,0x00,0x00,0x04,0xFF,0x00,0xAF,0x60,0x00,0x00,0x2D,0xFF,0xC1,0x06,0x88,0x88,0xFF,0x14,0xFF,0xD0,0x00,0x00,0x00,0xAF,0xC2,0x0C,0xFF,0xFC,0xFF,0x9F,0xF8,0x00,0x00,0x00,0x00,0x06,0x00,0x03,0x4C,0xF9,0xFF,0xFE,0x40,0x00,0x00,0x00,0x00,0x03,0x00,0x00,0x0D,0xF6,0xFF,0xFB,0x00,0x00,0x00,0x00,0x00,0x0B,0xE5,0x00,0x3F,0xD4,0xFF,0xFF,0x60,0x00,0x00,0x00,0x00,0x0F,0xF5,0x00,0xCF,0x74,0xFF,0x5F,0xF3,0x00,0x00,0x00,0x00,0x5F,0xF0,0x07,0xFF,0x14,0xFF,0x0A,0xFF,0x60,0x00,0x00,0x00,0xCF,0xA0,0x8F,0xF5,0x04,0xFF,0x01,0xDF,0xF9,0x00,0x00,0x04,0xFF,0x5A,0xFF,0xA0,0x04,0xFF,0x00,0x1D,0xF2,0x00,0x00,0x1D,0xFF,0x01,0xDA,0x03,0xFF,0xFF,0x00,0x01,0x60,0x00,0x00,0x27,0xEA,0x00,0x00,0x00,0xBF,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x47,0x30,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_20_2_5[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x35,0x00,0x00,0x00,0x09,0x40,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0x90,0x00,0x00,0xAF,0xFD,0x60,0x00,0x00,0x00,0x00,0x04,0xDF,0xFC,0x10,0x01,0x4C,0xFF,0xFE,0x20,0x00,0x00,0x00,0x00,0x1D,0xFD,0x20,0x54,0x44,0x8F,0xF6,0x00,0x00,0x00,0x00,0x00,0x01,0x81,0x00,0xFF,0xFF,0xFF,0x50,0x00,0x00,0x00,0x00,0x01,0x30,0x00,0x00,0xCC,0xCD,0xFF,0x00,0x27,0x00,0x00,0x00,0x3D,0xF8,0x00,0x00,0x00,0x04,0xFF,0x00,0xBF,0x60,0x00,0x00,0x4E,0xFF,0xD3,0x09,0xCC,0xCC,0xFF,0x24,0xFF,0xE1,0x00,0x00,0x01,0xCF,0xC1,0x0C,0xFF,0xFC,0xFF,0xCF,0xFB,0x10,0x00,0x00,0x00,0x07,0x00,0x03,0x4D,0xFB,0xFF,0xFF,0x50,0x00,0x00,0x00,0x00,0x03,0x00,0x00,0x0F,0xF7,0xFF,0xFC,0x00,0x00,0x00,0x00,0x00,0x0C,0xE6,0x00,0x5F,0xE4,0xFF,0xFF,0x70,0x00,0x00,0x00,0x00,0x1F,0xF6,0x00,0xCF,0x94,0xFF,0x8F,0xF6,0x00,0x00,0x00,0x00,0x6F,0xF1,0x0A,0xFF,0x24,0xFF,0x0C,0xFF,0x80,0x00,0x00,0x00,0xDF,0xB1,0xAF,0xF8,0x04,0xFF,0x01,0xEF,0xFA,0x00,0x00,0x05,0xFF,0x7C,0xFF,0xB2,0x04,0xFF,0x00,0x3F,0xF3,0x00,0x00,0x2F,0xFF,0x11,0xBA,0x12,0xFF,0xFF,0x00,0x03,0x80,0x00,0x00,0x27,0xEB,0x00,0x01,0x00,0xBF,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x69,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x38,0x10,0x00,0x00,0x08,0xFF,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0xD3,0x00,0x00,0x04,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xFF,0x52,0x44,0x04,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x0A,0xFB,0x18,0xFF,0x04,0xFF,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x60,0x08,0xFC,0x04,0xFF,0x27,0xDF,0x00,0x00,0x00,0x01,0x81,0x00,0x08,0xFC,0x06,0xFF,0xFF,0xFF,0x00,0x00,0x00,0x3E,0xFE,0x40,0x08,0xFF,0xEF,0xFF,0xFC,0xFF,0x00,0x00,0x00,0x08,0xFF,0xFA,0xAE,0xFF,0xFF,0xFF,0x04,0xFF,0x00,0x00,0x00,0x00,0x6F,0xA6,0xFF,0xFE,0x54,0xFF,0x04,0xFF,0x00,0x00,0x00,0x00,0x01,0x01,0xCC,0xFC,0x04,0xFF,0x04,0xFF,0x00,0x00,0x00,0x00,0x06,0x40,0x08,0xFC,0x04,0xFF,0x06,0xFF,0x00,0x00,0x00,0x00,0x0B,0xFC,0x08,0xFC,0x04,0xFF,0xFF,0xFF,0x00,0x00,0x00,0x00,0x1F,0xF7,0x08,0xFC,0x06,0xFF,0x7F,0xF6,0x00,0x00,0x00,0x00,0x6F,0xF2,0x08,0xFC,0x08,0xFF,0x14,0x05,0x00,0x00,0x00,0x00,0xCF,0xD0,0x08,0xFC,0x06,0xCC,0x00,0x0F,0xC5,0x00,0x00,0x06,0xFF,0x70,0x08,0xFF,0x64,0x44,0x44,0x8F,0xF9,0x00,0x00,0x1E,0xFF,0x20,0x03,0xFF,0xFF,0xFF,0xFF,0xFF,0xF3,0x00,0x00,0x00,0x69,0x00,0x00,0x9F,0xFF,0xFF,0xFF,0xFE,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x51,0x00,0x06,0xA2,0x00,0x06,0xD7,0x10,0x00,0x00,0x00,0x08,0xFF,0x30,0x0B,0xF8,0x00,0x0A,0xFC,0x00,0x00,0x00,0x00,0x03,0xFF,0xF5,0x06,0xFE,0x00,0x0F,0xF8,0x46,0x80,0x00,0x00,0x00,0x3F,0xFE,0x89,0xC8,0xB6,0x6F,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x06,0x3F,0xFF,0xFF,0xF8,0xEF,0xA8,0x88,0x80,0x00,0x00,0x03,0x10,0x08,0xEF,0x75,0x8C,0xFC,0x00,0x00,0x00,0x00,0x00,0x5F,0xF4,0x00,0xCF,0x40,0x6F,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x3F,0xFF,0x80,0xCF,0xFF,0xFC,0xDC,0x98,0xFF,0xE3,0x00,0x00,0x02,0xDF,0x40,0xCF,0xDE,0xF8,0x00,0x0A,0xFD,0x10,0x00,0x00,0x00,0x23,0x00,0xCF,0x48,0xF8,0x00,0xAF,0xF1,0x00,0x00,0x00,0x00,0x03,0x00,0xFF,0x28,0xF7,0xCC,0xFF,0xEC,0xC3,0x00,0x00,0x00,0x4F,0xB2,0xFF,0x0B,0xF8,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x8F,0xD5,0xFD,0x0C,0xF6,0x44,0xAF,0xA4,0x42,0x00,0x00,0x00,0xDF,0x89,0xF9,0x0C,0xF0,0x00,0x8F,0x80,0x00,0x00,0x00,0x03,0xFF,0x4F,0xF5,0x0E,0xF0,0x00,0x8F,0x80,0x00,0x00,0x00,0x0A,0xFE,0x8F,0xF7,0x6F,0xF0,0x20,0x8F,0x80,0x00,0x00,0x00,0x6F,0xFC,0xFF,0x66,0xFF,0xC0,0x8C,0xFF,0x80,0x00,0x00,0x00,0x28,0xE6,0xAD,0x00,0xFD,0x30,0x1F,0xFF,0x40,0x00,0x00,0x00,0x00,0x01,0x02,0x00,0x10,0x00,0x09,0xA4,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x35,0x00,0x00,0x00,0x09,0x40,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0x90,0x00,0x00,0xAF,0xFD,0x60,0x00,0x00,0x00,0x00,0x04,0xDF,0xFC,0x10,0x01,0x4C,0xFF,0xFE,0x20,0x00,0x00,0x00,0x00,0x1D,0xFD,0x20,0x54,0x44,0x8F,0xF6,0x00,0x00,0x00,0x00,0x00,0x01,0x81,0x00,0xFF,0xFF,0xFF,0x50,0x00,0x00,0x00,0x00,0x01,0x30,0x00,0x00,0xCC,0xCD,0xFF,0x00,0x27,0x00,0x00,0x00,0x3D,0xF8,0x00,0x00,0x00,0x04,0xFF,0x00,0xBF,0x60,0x00,0x00,0x4E,0xFF,0xD3,0x09,0xCC,0xCC,0xFF,0x24,0xFF,0xE1,0x00,0x00,0x01,0xCF,0xC1,0x0C,0xFF,0xFC,0xFF,0xCF,0xFB,0x10,0x00,0x00,0x00,0x07,0x00,0x03,0x4D,0xFB,0xFF,0xFF,0x50,0x00,0x00,0x00,0x00,0x03,0x00,0x00,0x0F,0xF7,0xFF,0xFC,0x00,0x00,0x00,0x00,0x00,0x0C,0xE6,0x00,0x5F,0xE4,0xFF,0xFF,0x70,0x00,0x00,0x00,0x00,0x1F,0xF6,0x00,0xCF,0x94,0xFF,0x8F,0xF6,0x00,0x00,0x00,0x00,0x6F,0xF1,0x0A,0xFF,0x24,0xFF,0x0C,0xFF,0x80,0x00,0x00,0x00,0xDF,0xB1,0xAF,0xF8,0x04,0xFF,0x01,0xEF,0xFA,0x00,0x00,0x05,0xFF,0x7C,0xFF,0xB2,0x04,0xFF,0x00,0x3F,0xF3,0x00,0x00,0x2F,0xFF,0x11,0xBA,0x12,0xFF,0xFF,0x00,0x03,0x80,0x00,0x00,0x27,0xEB,0x00,0x01,0x00,0xBF,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x69,0x50,0x00,0x00,0x00,0x00,0x00};
const uint8_t t_20_3[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x37,0x00,0x00,0x00,0x0A,0x60,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xB1,0x00,0x00,0xAF,0xFE,0x61,0x00,0x00,0x00,0x00,0x03,0xFF,0xFD,0x30,0x01,0x6E,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x3F,0xFD,0x20,0x88,0x44,0xAF,0xF6,0x00,0x00,0x00,0x00,0x00,0x03,0xA1,0x00,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x00,0x00,0x01,0x50,0x00,0x00,0xFC,0xCE,0xFF,0x40,0x48,0x00,0x00,0x00,0x3E,0xFA,0x10,0x00,0x00,0x08,0xFF,0x40,0xCF,0x60,0x00,0x00,0x4F,0xFF,0xE4,0x09,0xCC,0xCE,0xFF,0x45,0xFF,0xF2,0x00,0x00,0x02,0xDF,0xC1,0x0C,0xFF,0xFF,0xFF,0xCF,0xFC,0x20,0x00,0x00,0x00,0x18,0x00,0x06,0x8E,0xFF,0xFF,0xFF,0x70,0x00,0x00,0x00,0x00,0x05,0x00,0x00,0x0F,0xFC,0xFF,0xFD,0x00,0x00,0x00,0x00,0x00,0x0E,0xE6,0x00,0x6F,0xF8,0xFF,0xFF,0x90,0x00,0x00,0x00,0x00,0x2F,0xF9,0x01,0xEF,0xA8,0xFF,0xDF,0xF6,0x00,0x00,0x00,0x00,0x7F,0xF2,0x0A,0xFF,0x28,0xFF,0x5D,0xFF,0xA1,0x00,0x00,0x00,0xEF,0xD1,0xBF,0xF9,0x08,0xFF,0x42,0xFF,0xFC,0x00,0x00,0x07,0xFF,0x8C,0xFF,0xD3,0x28,0xFF,0x40,0x3F,0xF3,0x00,0x00,0x3F,0xFF,0x21,0xAD,0x12,0xFF,0xFF,0x40,0x03,0x90,0x00,0x00,0x38,0xED,0x00,0x01,0x00,0xBF,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x6B,0x61,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x44,0x00,0x00,0x00,0x00,0x00,0x00,0x3C,0x10,0x00,0x00,0x08,0xFF,0x00,0x00,0x00,0x00,0x00,0x03,0xFF,0xF4,0x00,0x00,0x08,0xFF,0x00,0x00,0x00,0x00,0x00,0x01,0xAF,0xFF,0x65,0x88,0x18,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x0A,0xFB,0x18,0xFF,0x08,0xFF,0x00,0x03,0x00,0x00,0x00,0x00,0x00,0x70,0x08,0xFF,0x08,0xFF,0x39,0xEF,0x00,0x00,0x00,0x02,0xA2,0x00,0x08,0xFF,0x0A,0xFF,0xFF,0xFF,0x00,0x00,0x00,0x3F,0xFF,0x50,0x08,0xFF,0xFF,0xFF,0xFE,0xFF,0x00,0x00,0x00,0x0A,0xFF,0xFB,0xBF,0xFF,0xFF,0xFF,0x18,0xFF,0x00,0x00,0x00,0x00,0x6F,0xA6,0xFF,0xFF,0x69,0xFF,0x08,0xFF,0x00,0x00,0x00,0x00,0x03,0x02,0xDC,0xFF,0x08,0xFF,0x04,0xFF,0x00,0x00,0x00,0x00,0x07,0x40,0x08,0xFF,0x08,0xFF,0x48,0xFF,0x00,0x00,0x00,0x00,0x0D,0xFC,0x08,0xFF,0x08,0xFF,0xFF,0xFF,0x00,0x00,0x00,0x00,0x2F,0xF9,0x08,0xFF,0x08,0xFF,0x7F,0xF6,0x00,0x00,0x00,0x00,0x7F,0xF3,0x08,0xFF,0x08,0xFF,0x34,0x44,0x00,0x00,0x00,0x00,0xEF,0xE0,0x08,0xFF,0x08,0xCC,0x30,0x4F,0xC5,0x00,0x00,0x07,0xFF,0x90,0x08,0xFF,0x87,0x88,0x88,0xAF,0xFB,0x00,0x00,0x3F,0xFF,0x30,0x06,0xFF,0xFF,0xFF,0xFF,0xFF,0xF5,0x00,0x00,0x00,0x6B,0x00,0x00,0xCF,0xFF,0xFF,0xFF,0xFF,0x90,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x63,0x00,0x06,0xA2,0x00,0x07,0xD7,0x10,0x00,0x00,0x00,0x09,0xFF,0x50,0x0D,0xFA,0x00,0x0B,0xFC,0x00,0x00,0x00,0x00,0x06,0xFF,0xF6,0x07,0xFF,0x00,0x1F,0xFC,0x88,0x80,0x00,0x00,0x00,0x6F,0xFF,0xCD,0xFC,0xC6,0x6F,0xFF,0xFF,0xF0,0x00,0x00,0x00,0x06,0x3F,0xFF,0xFF,0xF9,0xEF,0xA8,0x88,0xB0,0x00,0x00,0x03,0x20,0x08,0xEF,0xA8,0x8E,0xFE,0x00,0x00,0x00,0x00,0x00,0x6F,0xF6,0x00,0xCF,0x40,0x7F,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x6F,0xFF,0xA0,0xCF,0xFF,0xFF,0xDC,0xCD,0xFF,0xF3,0x00,0x00,0x03,0xFF,0x40,0xCF,0xFF,0xF9,0x10,0x1D,0xFD,0x10,0x00,0x00,0x00,0x33,0x00,0xEF,0x48,0xF8,0x00,0xCF,0xF2,0x00,0x00,0x00,0x00,0x13,0x00,0xFF,0x4B,0xFC,0xDC,0xFF,0xFC,0xE4,0x00,0x00,0x00,0x5F,0xB4,0xFF,0x0C,0xF8,0xFF,0xFF,0xFF,0xF4,0x00,0x00,0x00,0x9F,0xE6,0xFE,0x0C,0xF6,0x74,0xDF,0xA5,0x82,0x00,0x00,0x00,0xEF,0x9B,0xFA,0x0D,0xF4,0x00,0xCF,0x80,0x00,0x00,0x00,0x04,0xFF,0x6F,0xF6,0x0F,0xF0,0x00,0xCF,0x80,0x00,0x00,0x00,0x0C,0xFF,0x9F,0xF8,0x9F,0xF0,0x20,0xCF,0x80,0x00,0x00,0x00,0x7F,0xFF,0xFF,0x86,0xFF,0xD0,0x8D,0xFF,0x80,0x00,0x00,0x00,0x38,0xE7,0xAE,0x11,0xFE,0x60,0x1F,0xFF,0x60,0x00,0x00,0x00,0x00,0x01,0x03,0x00,0x30,0x00,0x09,0xC6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x37,0x00,0x00,0x00,0x0A,0x60,0x00,0x00,0x00,0x00,0x00,0x04,0xFF,0xB1,0x00,0x00,0xAF,0xFE,0x61,0x00,0x00,0x00,0x00,0x03,0xFF,0xFD,0x30,0x01,0x6E,0xFF,0xFF,0x30,0x00,0x00,0x00,0x00,0x3F,0xFD,0x20,0x88,0x44,0xAF,0xF6,0x00,0x00,0x00,0x00,0x00,0x03,0xA1,0x00,0xFF,0xFF,0xFF,0x80,0x00,0x00,0x00,0x00,0x01,0x50,0x00,0x00,0xFC,0xCE,0xFF,0x40,0x48,0x00,0x00,0x00,0x3E,0xFA,0x10,0x00,0x00,0x08,0xFF,0x40,0xCF,0x60,0x00,0x00,0x4F,0xFF,0xE4,0x09,0xCC,0xCE,0xFF,0x45,0xFF,0xF2,0x00,0x00,0x02,0xDF,0xC1,0x0C,0xFF,0xFF,0xFF,0xCF,0xFC,0x20,0x00,0x00,0x00,0x18,0x00,0x06,0x8E,0xFF,0xFF,0xFF,0x70,0x00,0x00,0x00,0x00,0x05,0x00,0x00,0x0F,0xFC,0xFF,0xFD,0x00,0x00,0x00,0x00,0x00,0x0E,0xE6,0x00,0x6F,0xF8,0xFF,0xFF,0x90,0x00,0x00,0x00,0x00,0x2F,0xF9,0x01,0xEF,0xA8,0xFF,0xDF,0xF6,0x00,0x00,0x00,0x00,0x7F,0xF2,0x0A,0xFF,0x28,0xFF,0x5D,0xFF,0xA1,0x00,0x00,0x00,0xEF,0xD1,0xBF,0xF9,0x08,0xFF,0x42,0xFF,0xFC,0x00,0x00,0x07,0xFF,0x8C,0xFF,0xD3,0x28,0xFF,0x40,0x3F,0xF3,0x00,0x00,0x3F,0xFF,0x21,0xAD,0x12,0xFF,0xFF,0x40,0x03,0x90,0x00,0x00,0x38,0xED,0x00,0x01,0x00,0xBF,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x6B,0x61,0x00,0x00,0x00,0x00,0x00};
	
void LCD_SetGTTest(uint8_t type)
{
	uint8_t x,y;
	SetWord_t word = {0};
	uint8_t *p_16,*p_18,*p_20,*p_24,*p_32;
	
	LCD_SetBackgroundColor(LCD_WHITE);
	
	if(type == 6)
	{
		x = 34;
		y = 80;
		LCD_SetTest(x,y,18,(uint8_t *)t_18_1_5);
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2)));
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*2)));
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*3)));	
		
		LCD_SetRectangle(80,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);
			
		x = 108;
		y = 68;
		LCD_SetTest(x,y,24,(uint8_t *)t_24_1_5);
		y += 26;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2)));
		y += 26;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*2)));
		y += 26;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*3)));	
		
		LCD_SetRectangle(160,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);	
			
		x = 188;
		y = 80;
		LCD_SetTest(x,y,18,(uint8_t *)t_18_1_5);
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2)));
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*2)));
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*3)));
	}
	else if(type == 7)
	{
		x = 32;
		y = 76;
		LCD_SetTest(x,y,20,(uint8_t *)t_20_1_5);
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2)));
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2*2)));
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2*3)));	
		
		LCD_SetRectangle(80,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);
			
		x = 108;
		y = 68;
		LCD_SetTest(x,y,24,(uint8_t *)t_24_1_5);
		y += 26;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2)));
		y += 26;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*2)));
		y += 26;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*3)));	
		
		LCD_SetRectangle(160,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);	
			
		x = 188;
		y = 76;
		LCD_SetTest(x,y,20,(uint8_t *)t_20_1_5);
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2)));
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2*2)));
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2*3)));
	}
	else if(type == 8)
	{
		x = 34;
		y = 80;
		LCD_SetTest(x,y,18,(uint8_t *)t_18_1_5);
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2)));
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*2)));
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*3)));	
		
		LCD_SetRectangle(80,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);
			
		x = 104;
		y = 52;
		LCD_SetTest(x,y,32,(uint8_t *)t_32_1_5);
		y += 34;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2)));
		y += 34;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2*2)));
		y += 34;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2*3)));	
		
		LCD_SetRectangle(160,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);	
			
		x = 188;
		y = 80;
		LCD_SetTest(x,y,18,(uint8_t *)t_18_1_5);
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2)));
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*2)));
		y += 20;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*3)));
	}
	else if(type == 9)
	{
		x = 32;
		y = 76;
		LCD_SetTest(x,y,20,(uint8_t *)t_20_1_5);
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2)));
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2*2)));
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2*3)));	
		
		LCD_SetRectangle(80,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);
			
		x = 104;
		y = 52;
		LCD_SetTest(x,y,32,(uint8_t *)t_32_1_5);
		y += 34;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2)));
		y += 34;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2*2)));
		y += 34;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2*3)));	
		
		LCD_SetRectangle(160,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);	
			
		x = 188;
		y = 76;
		LCD_SetTest(x,y,20,(uint8_t *)t_20_1_5);
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2)));
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2*2)));
		y += 22;
		LCD_SetTest(x,y,20,(uint8_t *)(t_20_1_5+(24*20/2*3)));
	}
	else  if(type == 10)
	{
		uint8_t i,j;
		x = 86;
		
		for(i = 0; i < 6; i++)
		{
			y = 48;
			for(j = 0; j < 2; j++)
			{
				LCD_SetTest(x,y,18,(uint8_t *)t_18_1_5);
				y += 18;
				LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2)));
				y += 18;
				LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*2)));
				y += 18;
				LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*3)));
				y += 18;
			}
			x += 20;
		}
	}
	else if(type == 11)
	{
		uint8_t i,j;
		x = 86;
		
		for(i = 0; i < 5; i++)
		{
			y = 24;
			for(j = 0; j < 2; j++)
			{
				LCD_SetTest(x,y,24,(uint8_t *)t_24_1_5);
				y += 24;
				LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2)));
				y += 24;
				LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*2)));
				y += 24;
				LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*3)));
				y += 24;
			}
			x += 26;
		}
	}
	else if(type == 12)
	{
		x = 34;
		y = 97;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*4)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*5)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*6)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*7)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*8)));
		
		LCD_SetRectangle(80,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);
			
		x = 108;
		y = 90;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*4)));
		y += 12;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*5)));
		y += 12;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*6)));
		y += 12;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*7)));
		y += 12;
		LCD_SetTest(x,y,24,(uint8_t *)(t_24_1_5+(24*24/2*7)));		
		
		LCD_SetRectangle(160,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);	
			
		x = 188;
		y = 97;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*4)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*5)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*6)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*7)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*8)));
	}
	else if(type == 13)
	{
		x = 34;
		y = 97;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*4)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*5)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*6)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*7)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*8)));	
		
		LCD_SetRectangle(80,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);
			
		x = 104;
		y = 80;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2*4)));
		y += 16;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2*5)));
		y += 16;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2*6)));
		y += 16;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2*7)));
		y += 16;
		LCD_SetTest(x,y,32,(uint8_t *)(t_32_1_5+(32*32/2*8)));
		
		LCD_SetRectangle(160,1,0,LCD_LINE_CNT_MAX,LCD_BLACK,0,0,LCD_FILL_ENABLE);	
			
		x = 188;
		y = 97;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*4)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*5)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*6)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*7)));
		y += 9;
		LCD_SetTest(x,y,18,(uint8_t *)(t_18_1_5+(24*18/2*8)));
	}
	else
	{
		word.x_axis = 48;
		word.y_axis = 66;
		word.size = LCD_FONT_32_SIZE;
		word.forecolor = LCD_BLACK;
		word.bckgrndcolor = LCD_NONE;
		
		if(type == 1)
		{
			LCD_SetString("1",&word);
			
			p_16 = (uint8_t *)t_16_1;
			p_18 = (uint8_t *)t_18_1;
			p_20 = (uint8_t *)t_20_1;
			p_24 = (uint8_t *)t_24_1;
			p_32 = (uint8_t *)t_32_1;
		}
		else if(type == 2)
		{
			LCD_SetString("1.5",&word);
			
			p_16 = (uint8_t *)t_16_1_5;
			p_18 = (uint8_t *)t_18_1_5;
			p_20 = (uint8_t *)t_20_1_5;
			p_24 = (uint8_t *)t_24_1_5;
			p_32 = (uint8_t *)t_32_1_5;
		}
		else if(type == 3)
		{
			LCD_SetString("2",&word);
			
			p_16 = (uint8_t *)t_16_2;
			p_18 = (uint8_t *)t_18_2;
			p_20 = (uint8_t *)t_20_2;
			p_24 = (uint8_t *)t_24_2;
			p_32 = (uint8_t *)t_32_2;
		}
		else if(type == 4)
		{
			LCD_SetString("2.5",&word);
			
			p_16 = (uint8_t *)t_16_2_5;
			p_18 = (uint8_t *)t_18_2_5;
			p_20 = (uint8_t *)t_20_2_5;
			p_24 = (uint8_t *)t_24_2_5;
			p_32 = (uint8_t *)t_32_2_5;
		}
		else
		{
			LCD_SetString("3",&word);
			
			p_16 = (uint8_t *)t_16_3;
			p_18 = (uint8_t *)t_18_3;
			p_20 = (uint8_t *)t_20_3;
			p_24 = (uint8_t *)t_24_3;
			p_32 = (uint8_t *)t_32_3;
		}

		x = 86;
		y = 16;
		LCD_SetTest(x,y,32,(uint8_t *)p_32);
		y += 36;
		LCD_SetTest(x,y,32,(uint8_t *)(p_32+(32*32/2)));
		y += 36;
		LCD_SetTest(x,y,32,(uint8_t *)(p_32+(32*32/2*2)));
		y += 36;
		LCD_SetTest(x,y,32,(uint8_t *)(p_32+(32*32/2*3)));
		if((type == 2) || ((type == 3)))
		{
			y += 32;
			LCD_SetTest(x,y,32,(uint8_t *)(p_32+(32*32/2*4)));
			y += 16;
			LCD_SetTest(x,y,32,(uint8_t *)(p_32+(32*32/2*5)));
			y += 16;
			LCD_SetTest(x,y,32,(uint8_t *)(p_32+(32*32/2*6)));
			y += 16;
			LCD_SetTest(x,y,32,(uint8_t *)(p_32+(32*32/2*7)));
			y += 16;
			LCD_SetTest(x,y,32,(uint8_t *)(p_32+(32*32/2*8)));
		}
		
		word.x_axis = x;
		word.y_axis = 22;
		word.size = LCD_FONT_32_SIZE;
//		LCD_SetString("32",&word);
		
		x += 36;
		y = 66;
		LCD_SetTest(x,y,24,(uint8_t *)p_24);
		y += 28;
		LCD_SetTest(x,y,24,(uint8_t *)(p_24+(24*24/2)));
		y += 28;
		LCD_SetTest(x,y,24,(uint8_t *)(p_24+(24*24/2*2)));
		y += 28;
		LCD_SetTest(x,y,24,(uint8_t *)(p_24+(24*24/2*3)));
		if((type == 2) || ((type == 3)))
		{
			y += 24;
			LCD_SetTest(x,y,24,(uint8_t *)(p_24+(24*24/2*4)));
			y += 12;
			LCD_SetTest(x,y,24,(uint8_t *)(p_24+(24*24/2*5)));
			y += 12;
			LCD_SetTest(x,y,24,(uint8_t *)(p_24+(24*24/2*6)));
			y += 12;
			LCD_SetTest(x,y,24,(uint8_t *)(p_24+(24*24/2*7)));
			y += 12;
			LCD_SetTest(x,y,24,(uint8_t *)(p_24+(24*24/2*8)));
		}
		
		word.x_axis = x;
		word.y_axis = 30;
		word.size = LCD_FONT_24_SIZE;
		LCD_SetString("24",&word);
		
		x += 28;
		y = 66;
		LCD_SetTest(x,y,20,(uint8_t *)p_20);
		y += 24;
		LCD_SetTest(x,y,20,(uint8_t *)(p_20+(24*20/2)));
		y += 24;
		LCD_SetTest(x,y,20,(uint8_t *)(p_20+(24*20/2*2)));
		y += 24;
		LCD_SetTest(x,y,20,(uint8_t *)(p_20+(24*20/2*3)));
		
		word.x_axis = x;
		word.y_axis = 38;
		word.size = LCD_FONT_16_SIZE;
		LCD_SetString("20",&word);
		
		x += 24;
		y = 66;
		LCD_SetTest(x,y,18,(uint8_t *)p_18);
		y += 22;
		LCD_SetTest(x,y,18,(uint8_t *)(p_18+(24*18/2)));
		y += 22;
		LCD_SetTest(x,y,18,(uint8_t *)(p_18+(24*18/2*2)));
		y += 22;
		LCD_SetTest(x,y,18,(uint8_t *)(p_18+(24*18/2*3)));
		if((type == 2) || ((type == 3)))
		{
			y += 18;
			LCD_SetTest(x,y,18,(uint8_t *)(p_18+(24*18/2*4)));
			y += 9;
			LCD_SetTest(x,y,18,(uint8_t *)(p_18+(24*18/2*5)));
			y += 9;
			LCD_SetTest(x,y,18,(uint8_t *)(p_18+(24*18/2*6)));
			y += 9;
			LCD_SetTest(x,y,18,(uint8_t *)(p_18+(24*18/2*7)));
			y += 9;
			LCD_SetTest(x,y,18,(uint8_t *)(p_18+(24*18/2*8)));
		}
		
		word.x_axis = x;
		word.size = LCD_FONT_16_SIZE;
		LCD_SetString("18",&word);
		
		x += 22;
		y = 66;
		LCD_SetTest(x,y,16,(uint8_t *)p_16);
		y += 20;
		LCD_SetTest(x,y,16,(uint8_t *)(p_16+(16*16/2)));
		y += 20;
		LCD_SetTest(x,y,16,(uint8_t *)(p_16+(16*16/2*2)));
		y += 20;
		LCD_SetTest(x,y,16,(uint8_t *)(p_16+(16*16/2*3)));
		if((type == 2) || ((type == 3)))
		{
			y += 16;
			LCD_SetTest(x,y,16,(uint8_t *)(p_16+(16*16/2*4)));
			y += 8;
			LCD_SetTest(x,y,16,(uint8_t *)(p_16+(16*16/2*5)));
			y += 8;
			LCD_SetTest(x,y,16,(uint8_t *)(p_16+(16*16/2*6)));
			y += 8;
			LCD_SetTest(x,y,16,(uint8_t *)(p_16+(16*16/2*7)));
			y += 8;
			LCD_SetTest(x,y,16,(uint8_t *)(p_16+(16*16/2*8)));
		}
		
		word.x_axis = x;
		word.size = LCD_FONT_16_SIZE;
		LCD_SetString("16",&word);
	}
	
//	x += 20;
//	y = 40;
//	LCD_SetTest(x,y,8,(uint8_t *)t_8);
//	y += 12;
//	LCD_SetTest(x,y,8,(uint8_t *)(t_8+(8*8/2)));
//	y += 12;
//	LCD_SetTest(x,y,8,(uint8_t *)(t_8+(8*8/2*2)));
//	y += 12;
//	LCD_SetTest(x,y,8,(uint8_t *)(t_8+(8*8/2*3)));
	
}
*/
/**
  * @brief  得到圆上某点的坐标
  * @param  centerx: Center X coordinate.
  * @param  centery: Center Y coordinate.
  * @param  angle: 以12点方向为起点，顺时针旋转角度(0-360)
  * @param  radius: 圆的半径
  * @retval p_x: 目标点X轴
  * @retval p_y: 目标点Y轴
  */
void get_circle_point(uint16_t centery, uint16_t centerx, uint16_t angle,
						uint16_t radius,uint16_t *p_x,uint16_t *p_y)
{
	int16_t ang;
	float pi = 3.1415926;
	
	angle = angle % 360;
	if(angle < 270)
	{
		ang = angle - 90;
	}
	else
	{
		ang = angle - 450;
	}
	
	*p_x = centerx + (radius * cos(ang * pi / 180.f));
	*p_y = centery + (radius * sin(ang * pi / 180.f));
}

static void draw_arc(uint8_t centery, uint8_t centerx, uint8_t radius, uint8_t thickness, 
						uint16_t startangle, uint16_t endangle, uint8_t pencolor)
{
	uint16_t i,j;
	int32_t a,b,c;
	uint16_t startx,starty;
	uint16_t endx,endy;
	uint16_t radius_max,radius_min;
	uint16_t x_max,y_max;
	uint16_t x_min,y_min;
	
	if(startangle > endangle)
	{
		return;
	}
	
	//外圈半径
	radius_max = radius;
	
	//内圈半径
	if(thickness < radius)
	{
		radius_min = radius - thickness;
	}
	else
	{
		radius_min = 0;
	}
	
	//圆弧起点和终点坐标
	get_circle_point(centery, centerx, startangle, radius_max, &startx,&starty);
	get_circle_point(centery, centerx, endangle, radius_max, &endx,&endy);
	
	//将图像整体向右移一个像素
//	centerx += 1;
	
	//防止超出边界
	y_max = centery + radius_max;
	if(y_max < LCD_LINE_CNT_MAX)
	{
		y_max += 1;
	}
	else
	{
		y_max = LCD_LINE_CNT_MAX;
	}
	
	if(centery < radius_max)
	{
		y_min = 0;
	}
	else
	{
		y_min = centery - radius_max;
	}
	
	x_max = centerx + radius_max;
	if(x_max < LCD_PIXEL_ONELINE_MAX)
	{
		x_max += 1;
	}
	else
	{
		x_max = LCD_PIXEL_ONELINE_MAX;
	}
	
	if(centerx < radius_max)
	{
		x_min = 0;
	}
	else
	{
		x_min = centerx - radius_max;
	}
	
	b = radius_max * radius_max;
	c = radius_min * radius_min;

	if(startangle < 180)
	{
		//起点在右半部分
		if(endangle < 180)
		{
			//终点在右半部分
			for(i = y_min; i < y_max; i++)
			{
				for(j = centerx; j < x_max; j++)
				{
					a = (i - centery)*(i - centery ) + (j - centerx)*(j - centerx);
					if(((a <= b) && (a >= c))
						&& ((startx - j)*(centery - i) - (starty - i) * (centerx - j) <= 0)
						&& ((endx - j)*(centery - i) - (endy - i) * (centerx - j) >= 0))
					{
						g_dispBuf[i][j] = pencolor;
					}
				}
			}
		}
		else
		{
			//终点在左半部分
			for(i = y_min; i < y_max; i++)
			{
				for(j = x_min; j < x_max; j++)
				{
					a = (i - centery)*(i - centery ) + (j - centerx)*(j - centerx);
					if((a <= b) && (a >= c))
					{
						if(j <= centerx)
						{
							//左半部分
							if((endx - j)*(centery - i) - (endy - i) * (centerx - j) >= 0)
							{
								g_dispBuf[i][j] = pencolor;
							}
						}
						else if(j > centerx)
						{
							//右半部分
							if((startx - j)*(centery - i) - (starty - i) * (centerx - j) <= 0)
							{
								g_dispBuf[i][j] = pencolor;
							}
						}
//						else
//						{
//							g_dispBuf[i][j] = pencolor;
//						}
					}
				}
			}
		}
	}
	else
	{
		//起点和终点都在左半部分
		for(i = y_min; i < y_max; i++)
		{
			for(j = x_min; j < centerx; j++)
			{
				a = (i - centery)*(i - centery ) + (j - centerx)*(j - centerx);
				if(((a <= b) && (a >= c))
					&& ((startx - j)*(centery - i) - (starty - i) * (centerx - j) <= 0)
					&& ((endx - j)*(centery - i) - (endy - i) * (centerx - j) >= 0))
				{
					g_dispBuf[i][j] = pencolor;
				}
			}
		}
	}
}

/**
  * @brief  Draw an arc (最大圆环耗时 < 55ms)
  * @param  centerx: Center X coordinate.
  * @param  centery: Center Y coordinate.
  * @param  radius: arc radius
  * @param  thickness: arc thickness.
  * @param  startangle: Start angle. 以12点方向为起点，顺时针旋转角度(0-359)
  * @param  endangle: End angle. 以12点方向为起点，顺时针旋转角度(0-360)
  * @param  pencolor: pen color.
  * @retval
  */
void LCD_SetArc(uint8_t centery, uint8_t centerx, uint8_t radius, uint8_t thickness, 
				uint16_t startangle, uint16_t endangle, uint8_t pencolor)
{	
	if((startangle == 0) && (endangle == 0))
	{
		return;
	}
	
	startangle = startangle % 360;
	endangle = (endangle == 360) ? endangle : (endangle % 360);
	
	if((startangle == endangle) || ((startangle + 360) == endangle))
	{
		//整圆环
		LCD_SetCircle(centery, centerx, radius, pencolor, thickness, LCD_FILL_DISABLE);
	}
	else
	{
		if(startangle < endangle)
		{
			//起始角度比终点角度小
			draw_arc(centery, centerx, radius, thickness, startangle, endangle, pencolor);
		}
		else
		{
			//起始角度比终点角度大
			draw_arc(centery, centerx, radius, thickness, startangle, 360, pencolor);
			draw_arc(centery, centerx, radius, thickness, 0, endangle, pencolor);
		}
	}
}

/**
  * @brief  Image/bitmap
  * @param  destx:  Destination X coordinate (0-239).
  * @param  desty:  Destination Y coordinate (0-239).
  * @param  forecolor:   Foreground color.
  * @param  bckgrndcolor:   Background color.
  * @param  imgParams:  Picture display parameters structure @ref LCD_ImgStruct
  * @retval
  */
void LCD_SetPicture( uint8_t destx, uint8_t desty, uint8_t forecolor, 
						uint8_t bckgrndcolor, const LCD_ImgStruct *imgParams)
{
	uint16_t i,j,k,x,y;
	uint8_t width,height,pxlen;
	uint8_t data,temp,back;
	uint8_t *p_font = NULL;
	
	x = destx;
	if( desty == LCD_CENTER_JUSTIFIED )
	{
		//居中显示
		if(imgParams->width > LCD_PIXEL_ONELINE_MAX)
		{
			y = 0;
		}
		else
		{
			y = (LCD_PIXEL_ONELINE_MAX - imgParams->width) / 2;
		}
	}
	else
	{
		y = desty;
	}
	
	p_font = (uint8_t *)imgParams->pxdata;
	
	height = imgParams->height;
	if((LCD_LINE_CNT_MAX - x) < height)
	{
		//防止溢出
		height = LCD_LINE_CNT_MAX - x;
	}
	
	width = imgParams->width;
	if((LCD_PIXEL_ONELINE_MAX - y) < width)
	{
		//防止溢出
		width = LCD_PIXEL_ONELINE_MAX - y;
	}
	
	switch(imgParams->imgtype)
	{
		case LCD_6BIT_COLOR:
			//显示带颜色的图
			for(i = 0; i < height; i++)
			{	
				for(j=0; j < width; j++)
				{
					//获取当前点数据
					data = *p_font++;
					if(forecolor != LCD_NONE)
					{
						data = (data & 0x88) | forecolor;
					}
					
					//获取当前点背景数据
					if(bckgrndcolor != LCD_NONE)
					{
						back = bckgrndcolor;
					}
					else
					{
						back = g_dispBuf[x+i][y+j];
					}
					
					switch(data & 0x88)
					{
						case 0x88:
							temp = data & 0x77;
							break;
						case 0x80:
							temp = (data & 0x70) | (back & 0x07);
							break;
						case 0x08:
							temp = (back & 0x70) | (data & 0x07);
							break;
						default:
							temp = back;
							break;
					}
					
					g_dispBuf[x+i][y+j] = temp;
				}
			}
			break;
		case LCD_1BIT_BITMAP:
			//显示点阵图
			pxlen = ceil(imgParams->width/8.f);
			for(i=0; i < height; i++)
			{
				for(j = 0; j < width; j++)
				{
					if(p_font[pxlen*i+j/8] & (0x80>>(j%8)))
					{
						g_dispBuf[x + i][y + j] = forecolor;
					}
					else
					{
						if(bckgrndcolor != LCD_NONE)
						{
							g_dispBuf[x + i][y + j] = bckgrndcolor;
						}
					}
				}
			}
			break;
		case LCD_2BPP_GRSCL:
			//2bit灰度图
			if(forecolor == LCD_NONE)
			{
				forecolor = LCD_BLACK;
			}
			
			for(i = 0; i < height; i++)
			{
				for(j = 0; j < width; )
				{
					//获取当前点数据
					data = *p_font++;
					for(k = 0; k < 4; k++)
					{
						//获取当前点背景数据
						if(bckgrndcolor != LCD_NONE)
						{
							back = bckgrndcolor;
						}
						else
						{
							back = g_dispBuf[x+i][y+j];
						}
						
						switch(data & 0x03)
						{
							case 0x00:
								temp = forecolor;
								break;
							case 0x01:
								temp = (forecolor & 0x70) | (back & 0x07);
								break;
							case 0x02:
								temp = (back & 0x70) | (forecolor & 0x07);
								break;
							default:
								temp = back;
								break;
						}
						
						g_dispBuf[x + i][y + j] = temp;
						
						j++;
						if(j >= width)
						{
							break;
						}
						
						data >>= 2;
					}
				}
			}
			break;
		default:
			break;
	}
}

/**
  * @brief  Display a char using a bitmap font set.
  * @param  fontCode:  pointer to text string.
  * @param  destx:  Destination X coordinate (0-239).
  * @param  desty:  Destination Y coordinate (0-239).
  * @param  forecolor:   Foreground color.
  * @param  bckgrndcolor:   Background color.
  * @param  charParams:  Char display parameters structure @ref LCD_CharStruct
  * @retval
  */
static void LCD_SetChar(uint8_t fontCode, uint8_t destx, uint8_t desty, uint8_t forecolor, 
						uint8_t bckgrndcolor, LCD_CharStruct *charParams)
{
	uint16_t i,j;
	uint32_t addr;
	uint16_t width,height;
	uint8_t pxlen;
	uint8_t *p_font = NULL;
	
	if((destx > LCD_LINE_CNT_MAX) || (desty > LCD_PIXEL_ONELINE_MAX)
		|| (fontCode < charParams->ascii_offset))
	{
		return;
	}
	
	p_font = (uint8_t *)charParams->pxdata;
	//根据字符宽度计算所占字节长度
	pxlen = ceil(charParams->width/8.f);
	//字符在字库中起始偏移地址
	addr = (fontCode - charParams->ascii_offset)*(charParams->height*pxlen);
	
	height = charParams->height;
	if((LCD_LINE_CNT_MAX - destx) < height)
	{
		//防止溢出
		height = LCD_LINE_CNT_MAX - destx;
	}
	
	width = charParams->width;
	if((LCD_PIXEL_ONELINE_MAX - desty) < width)
	{
		//防止溢出
		width = LCD_PIXEL_ONELINE_MAX - desty;
	}
	
	for(i = 0; i < height; i++)
	{	
		for(j = 0; j < width; j++)
		{	
			if(p_font[addr+pxlen*i+j/8] & (0x80>>(j%8)))
			{
				g_dispBuf[destx + i][desty + j] = forecolor;
			}
			else
			{
				if(bckgrndcolor != LCD_NONE)
				{
					g_dispBuf[destx + i][desty + j] = bckgrndcolor;
				}
			}
		}
	}
}

//void LCD_SetChar(char *code,SetWord_t *word)
//{
//	uint16_t x,y;
//	uint16_t i,j,n,len;
//	uint8_t width,height,star,pxlen;
//	uint8_t *p_font = NULL;
//	
//	if(code == NULL)
//	{
//		return;
//	}
//	
//	switch(word->size)
//	{
//		case LCD_FONT_16_SIZE:
//			p_font = (uint8_t *)Font_Char_16.pxdata;
//			width = Font_Char_16.width;
//			height = Font_Char_16.height;
//			star = Font_Char_16.ascii_offset;
//			break;
//		case LCD_FONT_24_SIZE:
//			p_font = (uint8_t *)Font_Char_24.pxdata;
//			width = Font_Char_24.width;
//			height = Font_Char_24.height;
//			star = Font_Char_24.ascii_offset;
//			break;
//		case LCD_FONT_32_SIZE:
//			p_font = (uint8_t *)Font_Char_32.pxdata;
//			width = Font_Char_32.width;
//			height = Font_Char_32.height;
//			star = Font_Char_32.ascii_offset;
//			break;
//		default:
//			return;
//	}
//	pxlen = ceil(width/8.f);
//	
//	x = word->x_axis;
//	if( word->y_axis == LCD_CENTER_JUSTIFIED )
//	{
//		//居中显示
//		len = (strlen(code)*(width + word->kerning)) - word->kerning;
//		if(len >= LCD_PIXEL_ONELINE_MAX)
//		{
//			y = 0;
//		}
//		else
//		{
//			y = (LCD_PIXEL_ONELINE_MAX - len) / 2;
//		}
//	}
//	else
//	{
//		y = word->y_axis;
//	}
//	
//	while(*code>0)
//	{
//		n = *code - star;
//		code++;
//		n *= (height*pxlen);
//		for(i = 0; i < height; i++)
//		{
//			if((x+i) >= LCD_PIXEL_ONELINE_MAX)
//			{
//				break;
//			}
//			for(j = 0; j < width; j++)
//			{
//				if(p_font[n+pxlen*i+j/8] & (0x80>>(j%8)))
//				{
//					g_dispBuf[x+i][y+j] = word->forecolor;
//				}
//				else
//				{
//					g_dispBuf[x+i][y+j] = word->bckgrndcolor;
//				}
//			}
//		}
//		y += (width + word->kerning);
//	}
//}

/**
  * @brief  Display a chinese using a bitmap font set.
  * @param  fontCode:  pointer to text string.
  * @param  destx:  Destination X coordinate (0-239).
  * @param  desty:  Destination Y coordinate (0-239).
  * @param  forecolor:   Foreground color.
  * @param  bckgrndcolor:   Background color.
  * @param  chinsesParams:  Chinese display parameters structure @ref LCD_ChineseStruct
  * @retval
  */
static void LCD_SetChinese(uint16_t fontCode, uint8_t destx, uint8_t desty, uint8_t forecolor, 
						   uint8_t bckgrndcolor, LCD_ChineseStruct *chineseParams)
{
	uint16_t i,j,n;
	uint32_t addr;
	uint8_t pxlen,width,height;
	uint16_t *p_index = NULL;
	uint8_t *p_font = NULL;
	
	if((destx > LCD_LINE_CNT_MAX) || (desty > LCD_PIXEL_ONELINE_MAX))
	{
		return;
	}

	p_index = (uint16_t *)chineseParams->pxindex;
	p_font = (uint8_t *)chineseParams->pxdata;
	
	//查找字符所在字库位置
	for( n = 0; n < chineseParams->num; n++ )
	{
		if( fontCode == p_index[n])
		{
			break;
		}
	}
	if(n == chineseParams->num)
	{
		//字库中没有此字符
		return;
	}
	
	//根据字符宽度计算所占字节长度
	pxlen = ceil(chineseParams->width/8.f);
	//字符在字库中起始偏移地址
	addr = n * (chineseParams->height * pxlen);
	
	height = chineseParams->height;
	if((LCD_LINE_CNT_MAX - destx) < height)
	{
		//防止溢出
		height = LCD_LINE_CNT_MAX - destx;
	}
	
	width = chineseParams->width;
	if((LCD_PIXEL_ONELINE_MAX - desty) < width)
	{
		//防止溢出
		width = LCD_PIXEL_ONELINE_MAX - desty;
	}
	
	for(i=0; i < height; i++)
	{
		for(j = 0; j < width; j++)
		{
			if(p_font[addr+pxlen*i+j/8] & (0x80>>(j%8)))
			{
				g_dispBuf[destx + i][desty + j] = forecolor;
			}
			else
			{
				if(bckgrndcolor != LCD_NONE)
				{
					g_dispBuf[destx + i][desty + j] = bckgrndcolor;
				}
			}
		}
	}
}

//void LCD_SetChinese(uint16_t fontCode, , SetWord_t *word)
//{
//	uint16_t i,j,n,x,y;
//	uint16_t num,temp,len;
//	uint8_t pxlen,width,height;
//	uint16_t *p_index = NULL;
//	uint8_t *p_font = NULL;
//	
//	if(code == NULL)
//	{
//		return;
//	}
//	
//	switch(word->size)
//	{
//		case LCD_FONT_16_SIZE:
//			p_index = (uint16_t *)Font_CN_16.pxindex;
//			p_font = (uint8_t *)Font_CN_16.pxdata;
//		    num = Font_CN_16.num;
//			width = Font_CN_16.width;
//			height = Font_CN_16.height;
//			break;
//		case LCD_FONT_24_SIZE:
//			p_index = (uint16_t *)Font_CN_24.pxindex;
//			p_font = (uint8_t *)Font_CN_24.pxdata;
//		    num = Font_CN_24.num;
//			width = Font_CN_24.width;
//			height = Font_CN_24.height;
//			break;
//		case LCD_FONT_32_SIZE:
//			p_index = (uint16_t *)Font_CN_32.pxindex;
//			p_font = (uint8_t *)Font_CN_32.pxdata;
//		    num = Font_CN_32.num;
//			width = Font_CN_32.width;
//			height = Font_CN_32.height;
//			break;
//		default:
//			return;
//	}
//	pxlen = ceil(width/8.f);
//	
//	x = word->x_axis;
//	if( word->y_axis == LCD_CENTER_JUSTIFIED )
//	{
//		len = ((strlen(code) / 2) * (width + word->kerning)) - word->kerning;
//		if(len >= LCD_PIXEL_ONELINE_MAX)
//		{
//			y = 0;
//		}
//		else
//		{
//			y = (LCD_PIXEL_ONELINE_MAX - len) / 2;
//		}
//	}
//	else
//	{
//		y = word->y_axis;
//	}
//	
//	while(*code>0)
//	{
//		temp = *code;
//		code++;
//		temp <<= 8;
//		temp |= *code;
//		code++;
//		for( n = 0;n < num;n++ )
//		{
//			if( temp == p_index[n])
//			{
//				break;
//			}
//		}
//		n *= (height * pxlen);
//		for(i=0; i < height; i++)
//		{
//			if((x+i) >= LCD_PIXEL_ONELINE_MAX)
//			{
//				//防止溢出
//				break;
//			}
//			for(j = 0; j < width; j++)
//			{
//				if(p_font[n+pxlen*i+j/8] & (0x80>>(j%8)))
//				{
//					g_dispBuf[x+i][y+j] = word->forecolor;
//				}
//				else
//				{
//					g_dispBuf[x+i][y+j] = word->bckgrndcolor;
//				}
//			}
//		}
//		y += (width + word->kerning);
//	}
//}

/**
  * @brief  Display a chinese string using a bitmap font set.
  * @param  code:  pointer to text string.
  * @param  word:  tring display parameters structure @ref SetWord_t
  * @retval
  */
void LCD_SetString(char *code,SetWord_t *word)
{
	uint16_t x,y,i;
	uint16_t cnnum = 0;
	uint16_t temp,num,len;
	LCD_CharStruct enParams = {0};
	LCD_ChineseStruct cnParams = {0};
	
	if(code == NULL)
	{
		return;
	}
	
	switch(word->size)
	{
		case LCD_FONT_16_SIZE:
			enParams = Font_Char_16;
			cnParams = Font_CN_16;
			break;

		default:
			return;
	}
	
	num = strlen(code);
	//获取中文个数
	for(i = 0; i < num;)
	{
		if(code[i]&0x80)
		{
			i += 2;
			cnnum += 1;
		}
		else
		{
			i += 1;
		}
	}
	
	x = word->x_axis;
	if(word->y_axis == LCD_CENTER_JUSTIFIED)
	{
		//居中显示
		len = num * enParams.width + (num - cnnum - 1)*word->kerning;
		if(len >= LCD_PIXEL_ONELINE_MAX)
		{
			y = 0;
		}
		else
		{
			y = (LCD_PIXEL_ONELINE_MAX - len) / 2;
		}
	}
	else
	{
		y = word->y_axis;
	}
	
	for(i = 0; i < num; )
	{
		if(*code&0x80)
		{
			//中文字符
			temp = *code;
			code++;
			temp <<= 8;
			temp |= *code;
			code++;
			
			LCD_SetChinese(temp, x, y, word->forecolor, word->bckgrndcolor, &cnParams);
			y += (cnParams.width + word->kerning);
			
			i += 2;
		}
		else
		{
			//英文字符
			temp = (*code & 0xFF);
			code++;
			
			LCD_SetChar(temp, x, y, word->forecolor, word->bckgrndcolor, &enParams);
			y += (enParams.width + word->kerning);
			
			i++;
		}
	}

}



