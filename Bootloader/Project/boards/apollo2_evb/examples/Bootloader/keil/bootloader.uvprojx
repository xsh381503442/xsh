# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf --bin --output bootloader\bootloader.bin bootloader\bootloader.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: YZL LAYER_BOOTLOADER RTT_LOG_ENABLED=0 AM_PACKAGE_BGA AM_PART_APOLLO2 keil AM_FREERTOS AM_HAL_DEBUG_NO_ASSERT
  c include: ..\src;..\..\..\..\..\User\External\Rtt;..\..\..\..\..\User\Library\Error;..\..\..\..\..\mcu\apollo2\hal;..\..\..\..\..\mcu\apollo2;..\..\..\..\..\utils;..\..\..\..\..\third_party\FreeRTOS9\Source\include;..\..\..\..\..\third_party\FreeRTOS9\Source\portable\Keil\AMapollo2;..\..\..\..\..\third_party\FreeRTOS9\Source\portable\MemMang;..\..\..\bsp;..\..\..\..\..\devices;..\..\..\..\..\User\Task\Rtos;..\..\..\..\..\User\Task\Setup;..\..\..\..\..\User\Task\Button;..\..\..\..\..\User\Driver\Button;..\..\..\..\..\User\Common\Apollo2;..\..\..\..\..\User\Driver\Motor;..\..\..\..\..\User\Device\Notify;..\..\..\..\..\bootloader;..\..\..\..\..\User\Driver\IntFlash;..\..\..\..\..\User\Library\Boot_setting;..\..\..\..\..\User\Library\Boot;..\..\..\..\..\User\Common\Utils;..\..\..\..\..\User\Device\DFU;..\..\..\..\..\User\Driver\HR;..\..\..\..\..\User\Driver\LCD;..\..\..\..\..\User\Driver\Buzzer;..\..\..\..\..\User\Driver\Axis6;..\..\..\..\..\User\Driver\Mag;..\..\..\..\..\User\Driver\PC;..\..\..\..\..\User\Driver\BLE;..\..\..\..\..\User\Task\PC;..\..\..\..\..\User\Device\HWT;..\..\..\..\..\User\Driver\ExtFlash;..\..\..\..\..\User\Device\ExtFlash;..\..\..\..\..\User\Command;..\..\..\..\..\User\Device\APP;..\..\..\..\..\User\Task\BLE;..\..\..\..\..\User\Device\BLE;..\..\..\..\..\User\Driver\LCD;..\..\..\..\..\User\Device\LCD;..\..\..\..\..\User\Library\Display;..\..\..\..\..\User\DotFactory;..\..\..\..\..\User\Driver\RTC;..\..\..\..\..\User\Timer\Wakeup;..\..\..\..\..\User\Driver\ADC;..\..\..\..\..\User\Device\Battery;..\..\..\..\..\User\Task\Charge;..\..\..\..\..\User\Timer\Notify;..\..\..\..\..\User\Library\gfx;..\..\..\..\..\User\GUI\Boot;..\..\..\..\..\User\Lib\BOSH\algo_bsx\Inc;..\..\..\..\..\User\font;..\..\..\..\..\User\Task\Display;..\..\..\..\..\User\Timer\Bootloader;..\..\..\..\..\User\Timer\Exception;..\..\..\..\..\User\GUI\POST_WATCH_INFO;..\..\..\..\..\User\GUI\EXCEPTION;..\..\..\..\..\User\BSP;..\..\..\..\..\User\GUI\BACK_DOOR
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x40000
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group App
    ../src/: main.c
  group Board
    ../../../../../User/BSP/: board.h YZL_BSP.c
  group GUI
    ../../../../../User/GUI/Boot/: gui_boot.c
    ../../../../../User/GUI/POST_WATCH_INFO/: gui_post_watch_info.c
    ../../../../../User/GUI/EXCEPTION/: gui_exception.c
    ../../../../../User/GUI/BACK_DOOR/: gui_back_door.c
  group Task
    ../src/: FreeRTOSConfig.h
    ../../../../../User/Task/Rtos/: task_rtos.c
    ../../../../../User/Task/Setup/: task_setup.c
    ../../../../../User/Task/Button/: task_button.c
    ../../../../../User/Task/PC/: task_pc.c
    ../../../../../User/Task/BLE/: task_ble.c
    ../../../../../User/Task/Charge/: task_charge.c
    ../../../../../User/Task/Display/: task_display.c
  group Timer
    ../../../../../User/Timer/Bootloader/: timer_boot.c
    ../../../../../User/Timer/Exception/: timer_exception.c
  group Device
    ../../../../../User/Device/DFU/: dev_dfu.c dev_dfu_ble.c
    ../../../../../User/Device/ExtFlash/: dev_extFlash.c
    ../../../../../User/Device/APP/: dev_app.c
    ../../../../../User/Device/BLE/: dev_ble.c
    ../../../../../User/Device/LCD/: dev_lcd.c
    ../../../../../User/Device/Battery/: dev_bat.c
  group Driver
    ../../../../../User/Driver/Button/: drv_button.c
    ../../../../../User/Driver/IntFlash/: drv_intFlash.c
    ../../../../../User/Driver/ExtFlash/: drv_extFlash.c
    ../../../../../User/Driver/PC/: drv_pc.c
    ../../../../../User/Driver/BLE/: drv_ble.c
    ../../../../../User/Driver/RTC/: drv_rtc.c
    ../../../../../User/Driver/LCD/: drv_lcd.c
  group Common
    ../../../../../User/Common/Apollo2/: com_apollo2.c
    ../../../../../User/Common/Utils/: com_utils.c
  group Library
    ../../../../../User/Library/Error/: lib_error.c
    ../../../../../User/Library/Boot/: lib_boot.c
    ../../../../../User/Library/Boot_setting/: lib_boot_setting.c
  group Cmd
    ../../../../../User/Command/: cmd_pc.h cmd_ble.h
  group Rtt
    ../../../../../User/External/Rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c rtt_log.c
  group Source
    ../../../../../third_party/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group AMapollo2
    ../../../../../third_party/FreeRTOS9/Source/portable/Keil/AMapollo2/: port.c
  group MemMang
    ../../../../../third_party/FreeRTOS9/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
  group keil
    ./: startup_keil.s
  group hal
    ../../../../../mcu/apollo2/hal/: am_hal_adc.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_i2c_bit_bang.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_otp.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_ttp.c am_hal_uart.c am_hal_vcomp.c am_hal_wdt.c
  group utils
    ../../../../../utils/: am_util_cmdline.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_math.c am_util_plot.c am_util_regdump.c am_util_ring_buffer.c am_util_stdio.c am_util_stopwatch.c am_util_string.c am_util_stxetx.c am_util_tap_detect.c am_util_time.c
  group am_boot
    ../../../../../bootloader/: am_bootloader.c
  group am_device
    ../../../../../devices/: am_devices_spiflash.c am_devices_button.c
    ../../../bsp/: am_bsp.c
  group bsp
    ../../../bsp/: am_bsp.c am_bsp.h am_bsp_gpio.h
  group font
    ../../../../../User/font/: font_char.c font_chinese.c
target application (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: as above
  output: application +hex
  AfterMake: fromelf --bin --output application\application.bin application\application.axf
  AfterMake: cp application\application.bin ..\..\..\..\..\..\output\download_tool\Application
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: LAYER_APPLICATION RTT_LOG_ENABLED=0 BOSH_OFFICIAL_SITE_API AM_PACKAGE_BGA AM_PART_APOLLO2 keil AM_FREERTOS AM_HAL_DEBUG_NO_ASSERT DEBUG_ENABLED
  c include: ..\src;..\..\..\..\..\User\External\Rtt;..\..\..\..\..\User\Library\Error;..\..\..\..\..\mcu\apollo2\hal;..\..\..\..\..\mcu\apollo2;..\..\..\..\..\utils;..\..\..\..\..\third_party\FreeRTOS9\Source\include;..\..\..\..\..\third_party\FreeRTOS9\Source\portable\Keil\AMapollo2;..\..\..\..\..\third_party\FreeRTOS9\Source\portable\MemMang;..\..\..\bsp;..\..\..\..\..\devices;..\..\..\..\..\User\Task\Rtos;..\..\..\..\..\User\Task\Setup;..\..\..\..\..\User\Task\Button;..\..\..\..\..\User\Driver\Button;..\..\..\..\..\User\Common\Apollo2;..\..\..\..\..\User\Driver\Motor;..\..\..\..\..\User\Device\Notify;..\..\..\..\..\bootloader;..\..\..\..\..\User\Driver\IntFlash;..\..\..\..\..\User\Library\Boot_setting;..\..\..\..\..\User\Library\Boot;..\..\..\..\..\User\Common\Utils;..\..\..\..\..\User\Device\DFU;..\..\..\..\..\User\Device\HWT;..\..\..\..\..\User\Driver\PC;..\..\..\..\..\User\Device\ExtFlash;..\..\..\..\..\User\Driver\ExtFlash;..\..\..\..\..\User\Task\PC;..\..\..\..\..\User\Command;..\..\..\..\..\User\Device\APP;..\..\..\..\..\User\Device\BLE;..\..\..\..\..\User\Driver\BLE;..\..\..\..\..\User\Task\BLE;..\..\..\..\..\User\Common\Register;..\..\..\..\..\User\Library\Display;..\..\..\..\..\User\Device\LCD;..\..\..\..\..\User\Driver\LCD;..\..\..\..\..\User\Library\gfx;..\..\..\..\..\User\DotFactory;..\..\..\..\..\User\Driver\RTC;..\..\..\..\..\User\GUI\Home;..\..\..\..\..\User\Timer\Wakeup;..\..\..\..\..\User\Device\Battery;..\..\..\..\..\User\Task\Charge;..\..\..\..\..\User\GUI\Menu;..\..\..\..\..\User\GUI\BLE;..\..\..\..\..\User\GUI\Util;..\..\..\..\..\User\GUI\AXIS6;..\..\..\..\..\User\GUI\MAG;..\..\..\..\..\User\GUI\GPS;..\..\..\..\..\User\GUI\Heartrate;..\..\..\..\..\User\Timer\Notify;..\..\..\..\..\User\GUI\Notify;..\..\..\..\..\User\Library\gfx;..\..\..\..\..\User\Driver\GPS;..\..\..\..\..\User\Device\GPS;..\..\..\..\..\User\Device\Heartrate;..\..\..\..\..\User\Lib\BOSH\BMI160_driver-master;..\..\..\..\..\User\Driver\BOSH_OFFICIAL_API;..\..\..\..\..\User\Driver\BOSH_KEIL_API;..\..\..\..\..\User\Lib\BOSH\BOSH_KEIL\device;..\..\..\..\..\User\Lib\BOSH\BOSH_KEIL\device\API\BMI160_API;..\..\..\..\..\User\Lib\BOSH\BOSH_KEIL\device\API\BMM050_API;..\..\..\..\..\User\Lib\BOSH\BOSH_KEIL\algo\algo_bsx\Inc;..\..\..\..\..\User\Lib\BOSH\BSXlite_Cortex_M3_M4_M4F\algo\algo_bsx\Inc;..\..\..\..\..\User\Timer\Sensor;..\..\..\..\..\User\GUI\POF;..\..\..\..\..\User\Driver\Font;..\..\..\..\..\User\Device\Font;..\..\..\..\..\User\GUI\Font;..\..\..\..\..\User\Lib\GT;..\..\..\..\..\User\GUI\HWT;..\..\..\..\..\User\Driver\BackLight
  memory RVCT4: ROM 0x10000 size 0xe2000
  memory RVCT9: RAM 0x10000000 size 0x40000
  link misc: as above
