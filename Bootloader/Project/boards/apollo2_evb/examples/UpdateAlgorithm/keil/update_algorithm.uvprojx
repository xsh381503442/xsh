# Keil uVision project update_algorithm.uvprojx, settings and files
target update_algorithm (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: update_algorithm +hex
  AfterMake: fromelf --bin --output bin\update_algorithm.bin bin\update_algorithm.axf
  AfterMake: cp bin\update_algorithm.bin ..\..\..\..\..\..\..\..\output\download_tool\UpdateAlgorithm
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: YZL LAYER_UPDATEALGORITHM AM_PACKAGE_BGA AM_PART_APOLLO2 keil AM_HAL_DEBUG_NO_ASSERT
  c include: ../src;../../../bsp;../../../../..;../../../../../utils;../../../../../devices;../../../../../mcu/apollo2;..\..\..\..\..\User\External\Rtt;..\..\..\..\..\User\Library\Error;..\..\..\..\..\User\Library\Scheduler;..\..\..\..\..\User\Common\Utils;..\..\..\..\..\User\Common\Apollo2;..\..\..\..\..\User\Device\DFU;..\..\..\..\..\User\Scheduler\Button;..\..\..\..\..\User\Scheduler\Button;..\..\..\..\..\bootloader;..\..\..\..\..\User\Library\Boot;..\..\..\..\..\User\Library\Boot_setting;..\..\..\..\..\User\Driver\IntFlash;..\..\..\..\..\User\Device\ExtFlash;..\..\..\..\..\User\Driver\ExtFlash;..\..\..\..\..\User\Driver\PC;..\..\..\..\..\User\Scheduler\PC;..\..\..\..\..\User\Command;..\..\..\..\..\User\BSP
  memory RVCT4: ROM 0xfc000 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x40000
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group App
    ../src/: main.c
  group Board
    ../../../../../User/BSP/: board.h YZL_BSP.c
  group Scheduler
    ../../../../../User/Scheduler/Button/: sched_button.c
    ../../../../../User/Scheduler/PC/: sched_pc.c
  group Device
    ../../../../../User/Device/DFU/: dev_dfu.c
    ../../../../../User/Device/ExtFlash/: dev_extFlash.c
  group Driver
    ../../../../../User/Driver/IntFlash/: drv_intFlash.c
    ../../../../../User/Driver/ExtFlash/: drv_extFlash.c
    ../../../../../User/Driver/PC/: drv_pc.c
  group Common
    ../../../../../User/Common/Apollo2/: com_apollo2.c
    ../../../../../User/Common/Utils/: com_utils.c
  group Library
    ../../../../../User/Library/Error/: lib_error.c
    ../../../../../User/Library/Scheduler/: lib_scheduler.c
    ../../../../../User/Library/Boot/: lib_boot.c
    ../../../../../User/Library/Boot_setting/: lib_boot_setting.c
  group Cmd
    ../../../../../User/Command/: cmd_pc.h
  group Rtt
    ../../../../../User/External/Rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c rtt_log.c
  group keil
    ./: startup_keil.s
  group hal
    ../../../../../mcu/apollo2/hal/: am_hal_adc.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_i2c_bit_bang.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_otp.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_ttp.c am_hal_uart.c am_hal_vcomp.c am_hal_wdt.c
  group utils
    ../../../../../utils/: am_util_cmdline.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_math.c am_util_plot.c am_util_regdump.c am_util_ring_buffer.c am_util_stdio.c am_util_stopwatch.c am_util_string.c am_util_stxetx.c am_util_tap_detect.c am_util_time.c
  group am_boot
    ../../../../../bootloader/: am_bootloader.c
