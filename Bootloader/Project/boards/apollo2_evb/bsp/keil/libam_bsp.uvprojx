# Keil uVision project libam_bsp.uvprojx, settings and files
target libam_bsp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: libam_bsp (library)
  AfterMake: fromelf --bin --output bin\libam_bsp.bin bin\libam_bsp.axf
  AfterMake: fromelf -cedrst --output bin\libam_bsp.txt bin\libam_bsp.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO2 keil
  c include: ../../../../mcu/apollo2;../../../../devices
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x40000
  link misc: ../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group source_files
    ../: am_bsp.c
