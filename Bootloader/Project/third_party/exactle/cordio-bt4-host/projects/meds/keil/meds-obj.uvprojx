# Keil uVision project meds-obj.uvprojx, settings and files
target meds-obj (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: bt4_modb-meds +hex
  AfterMake: fromelf.exe --bin --output _build/bt4_modb-meds.bin _build/bt4_modb-meds.axf
  AfterMake: python ../../pack_all.py  _build/bt4_modb-meds.bin  ../../../../cordio-bt4-host/platform/cordio-bt4/img/ASIC-2.0-ble_ctr.img _build/bt4_modb-meds.img  _build/bt4_modb-meds.spf old
  c flags: Optim=4 uC99=1 wLevel=2
  c define: INIT_FLASH=1 INIT_WAKEUP=1 INIT_GPO=1 WSF_MS_PER_TICK=10 WSF_TOKEN_ENABLED=FALSE WSF_TRACE_ENABLED=TRUE WSF_PRINTF_MAX_LEN=128 ASIC CONFIG_HOST_REV=0x20 CONFIG_ALLOW_DEEP_SLEEP=FALSE WSF_MAX_HANDLERS=20 WSF_ASSERT_ENABLED=TRUE
  c misc: --wchar16
  c include: ..\..\..\..\cordio-bt4-host\projects\common;..\..\..\..\cordio-bt4-host\projects\common;..\..\..\..\cordio-bt4-host\projects\chip\smd_tc2;..\..\..\platform;..\..\..\platform\cordio-bt4\inc;..\..\..\platform\CMSIS\Include;..\..\..\platform\CMSIS\Device\SMD\TC\Include;..\..\..\sw\llc\include;..\..\..\sw\hci;..\..\..\..\sw\apps\app;..\..\..\..\sw\apps\app\include;..\..\..\..\sw\apps\meds;..\..\..\..\sw\hci\dual_chip;..\..\..\..\sw\hci\include;..\..\..\..\sw\profiles\blps;..\..\..\..\sw\profiles\htps;..\..\..\..\sw\profiles\glps;..\..\..\..\sw\profiles\plxps;..\..\..\..\sw\profiles\wsps;..\..\..\..\ws-core\include;..\..\..\..\sw\services;..\..\..\..\sw\stack\cfg;..\..\..\..\sw\stack\hci;..\..\..\..\sw\stack\include;..\..\..\..\sw\mac\cfg;..\..\..\..\sw\mac\include;..\..\..\..\sw\mac\ble\include;..\..\..\..\sw\mac\ble\lctr;..\..\..\..\ws-core\sw\util;..\..\..\..\ws-core\sw\wsf\common;..\..\..\..\ws-core\sw\wsf\generic;..\..\..\..\ws-core\sw\wsf\include;..\..\..\..\sw\stack\dm;..\..\..\..\sw\stack\smp;..\..\..\..\sw\sec\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --first systemVectors
  group startup
    ../: main.c
    ../../../platform/CMSIS/Device/SMD/TC/Source/: system_smd_tc2.c
    ../../../platform/CMSIS/Device/SMD/TC/Source/MDK/: startup-smd_tc2.s
    ../../../platform/CMSIS/Device/SMD/TC/Include/: system_smd_tc.h SMD_TC2.h
  group board
    ../../common/: board.c board.h main_time.c main_time.h utils.c
    ../../../platform/: board_flash.c board_flash.h platform.c platform.h cordio_tc2.c cordio_tc2.h
    ../../../sw/llc/cordio-tc2/: llc.c
    ../../../sw/llc/generic/: llc_hci.c llc_init.c
  group app
    ../../../../sw/apps/meds/: meds_main.c meds_htp.c meds_wsp.c meds_glp.c meds_blp.c meds_plx.c
    ../../../sw/app/: app_ui.c app_param.c
    ../../../../sw/apps/app/: app_main.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../../../sw/apps/app/generic/: app_hw.c app_db.c
    ../../../../sw/profiles/blps/: blps_main.c
    ../../../../sw/profiles/htps/: htps_main.c
    ../../../../sw/profiles/wsps/: wsps_main.c
    ../../../../sw/profiles/plxps/: plxps_main.c plxps_db.c
    ../../../../sw/profiles/glps/: glps_main.c glps_db.c
    ../../../../sw/services/: svc_core.c svc_bps.c svc_dis.c svc_hts.c svc_wp.c svc_wss.c svc_gls.c svc_plxs.c
  group sec
    ../../../../sw/sec/common/: sec_main.c sec_aes.c sec_cmac.c sec_ecc_hci.c
  group stack
    ../../../../sw/stack/cfg/: cfg_stack.c
    ../../../../sw/stack/att/: att_main.c att_uuid.c attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c
    ../../../../sw/stack/dm/: dm_adv.c dm_adv_leg.c dm_adv_priv.c dm_conn.c dm_conn_master.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_main.c dm_priv.c dm_scan.c dm_scan_leg.c dm_sec.c dm_sec_master.c dm_sec_slave.c dm_sec_lesc.c
    ../../../../sw/stack/l2c/: l2c_main.c l2c_master.c l2c_slave.c
    ../../../../sw/stack/smp/: smp_act.c smp_main.c smp_non.c smpi_act.c smpi_sm.c smpr_act.c smpr_sm.c smp_sc_act.c smp_sc_main.c smpi_sc_act.c smpi_sc_sm.c smpr_sc_act.c smpr_sc_sm.c
  group hci
    ../../../../sw/hci/dual_chip/: hci_cmd.c hci_core_ps.c hci_core_ps.h hci_evt.c
    ../../../sw/hci/: hci_tr.c hci_vs.c
    ../../../../sw/hci/generic/: hci_core.c
    ../../../../sw/stack/hci/: hci_main.c hci_main.h
  group wsf
    ../../../sw/wsf/: wsf_trace.c wsf_assert.c
    ../../../../ws-core/sw/wsf/common/: wsf_buf.c wsf_msg.c wsf_queue.c wsf_timer.c
    ../../../../ws-core/sw/wsf/generic/: wsf_os.c
  group util
    ../../../../ws-core/sw/util/: bda.c calc128.c bstream.c
