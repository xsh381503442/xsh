# Keil uVision project medc-obj.uvprojx, settings and files
target medc-obj (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: bt4_modb-medc +hex
  AfterMake: fromelf.exe --bin --output _build/bt4_modb-medc.bin _build/bt4_modb-medc.axf
  AfterMake: python ../../pack_all.py  _build/bt4_modb-medc.bin  ../../../../cordio-bt4-host/platform/cordio-bt4/img/ASIC-2.0-ble_ctr.img _build/bt4_modb-medc.img  _build/bt4_modb-medc.spf old
  c flags: Optim=4 uC99=1 wLevel=2
  c define: INIT_FLASH=1 INIT_WAKEUP=1 INIT_GPO=1 WSF_MS_PER_TICK=10 WSF_TOKEN_ENABLED=FALSE WSF_TRACE_ENABLED=TRUE WSF_PRINTF_MAX_LEN=128 ASIC CONFIG_HOST_REV=0x20 CONFIG_ALLOW_DEEP_SLEEP=FALSE WSF_MAX_HANDLERS=20 WSF_ASSERT_ENABLED=TRUE
  c misc: --wchar16
  c include: ..\..\..\..\cordio-bt4-host\projects\common;..\..\..\..\cordio-bt4-host\projects\common;..\..\..\..\cordio-bt4-host\projects\chip\smd_tc2;..\..\..\platform;..\..\..\platform\cordio-bt4\inc;..\..\..\platform\CMSIS\Include;..\..\..\platform\CMSIS\Device\SMD\TC\Include;..\..\..\sw\llc\include;..\..\..\sw\hci;..\..\..\..\sw\apps\app;..\..\..\..\sw\apps\app\include;..\..\..\..\sw\apps\medc;..\..\..\..\sw\hci\dual_chip;..\..\..\..\sw\hci\include;..\..\..\..\sw\profiles\blpc;..\..\..\..\sw\profiles\glpc;..\..\..\..\sw\profiles\hrpc;..\..\..\..\sw\profiles\htpc;..\..\..\..\sw\profiles\dis;..\..\..\..\sw\profiles\gatt;..\..\..\..\sw\profiles\plxpc;..\..\..\..\sw\profiles\wspc;..\..\..\..\ws-core\include;..\..\..\..\sw\services;..\..\..\..\sw\stack\cfg;..\..\..\..\sw\stack\hci;..\..\..\..\sw\stack\include;..\..\..\..\sw\mac\cfg;..\..\..\..\sw\mac\include;..\..\..\..\sw\mac\ble\include;..\..\..\..\sw\mac\ble\lctr;..\..\..\..\ws-core\sw\util;..\..\..\..\ws-core\sw\wsf\common;..\..\..\..\ws-core\sw\wsf\generic;..\..\..\..\ws-core\sw\wsf\include;..\..\..\..\sw\stack\dm;..\..\..\..\sw\stack\smp;..\..\..\..\sw\sec\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --first systemVectors
  group startup
    ../: main.c
    ../../../platform/CMSIS/Device/SMD/TC/Source/: system_smd_tc2.c
    ../../../platform/CMSIS/Device/SMD/TC/Source/MDK/: startup-smd_tc2.s
    ../../../platform/CMSIS/Device/SMD/TC/Include/: system_smd_tc.h SMD_TC2.h
  group board
    ../../common/: board.c board.h main_time.c main_time.h utils.c
    ../../../platform/: board_flash.c board_flash.h platform.c platform.h cordio_tc2.c cordio_tc2.h
    ../../../sw/llc/cordio-tc2/: llc.c
    ../../../sw/llc/generic/: llc_hci.c llc_init.c
  group app
    ../../../sw/app/: app_ui.c app_param.c
    ../../../../sw/apps/app/: app_main.c app_disc.c app_master.c app_master_leg.c app_server.c app_terminal.c
    ../../../../sw/apps/app/generic/: app_db.c app_hw.c
    ../../../../sw/services/: svc_core.c
    ../../../../sw/apps/medc/: medc_main.c medc_blp.c medc_glp.c medc_hrp.c medc_htp.c medc_plx.c medc_wsp.c
    ../../../../sw/profiles/gatt/: gatt_main.c
    ../../../../sw/profiles/dis/: dis_main.c
    ../../../../sw/profiles/glpc/: glpc_main.c
    ../../../../sw/profiles/hrpc/: hrpc_main.c
    ../../../../sw/profiles/htpc/: htpc_main.c
    ../../../../sw/profiles/wspc/: wspc_main.c
    ../../../../sw/profiles/blpc/: blpc_main.c
    ../../../../sw/profiles/plxpc/: plxpc_main.c
  group sec
    ../../../../sw/sec/common/: sec_main.c sec_aes.c sec_cmac.c sec_ecc_hci.c
  group stack
    ../../../../sw/stack/cfg/: cfg_stack.c
    ../../../../sw/stack/att/: att_main.c att_uuid.c attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c
    ../../../../sw/stack/dm/: dm_adv.c dm_adv_leg.c dm_adv_priv.c dm_conn.c dm_conn_master.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_main.c dm_priv.c dm_scan.c dm_scan_leg.c dm_sec.c dm_sec_master.c dm_sec_slave.c dm_sec_lesc.c
    ../../../../sw/stack/l2c/: l2c_main.c l2c_master.c l2c_slave.c
    ../../../../sw/stack/smp/: smp_act.c smp_main.c smp_non.c smpi_act.c smpi_sm.c smpr_act.c smpr_sm.c smp_sc_act.c smp_sc_main.c smpi_sc_act.c smpi_sc_sm.c smpr_sc_act.c smpr_sc_sm.c
  group hci
    ../../../../sw/hci/dual_chip/: hci_cmd.c hci_core_ps.c hci_core_ps.h hci_evt.c
    ../../../sw/hci/: hci_tr.c hci_vs.c
    ../../../../sw/hci/generic/: hci_core.c
    ../../../../sw/stack/hci/: hci_main.c hci_main.h
  group wsf
    ../../../sw/wsf/: wsf_trace.c wsf_assert.c
    ../../../../ws-core/sw/wsf/common/: wsf_buf.c wsf_msg.c wsf_queue.c wsf_timer.c
    ../../../../ws-core/sw/wsf/generic/: wsf_os.c
  group util
    ../../../../ws-core/sw/util/: bda.c calc128.c bstream.c
