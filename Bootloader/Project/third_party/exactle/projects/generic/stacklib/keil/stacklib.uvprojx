# Keil uVision project stacklib.uvprojx, settings and files
target stacklib (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: stacklib (library)
  c flags: Optim=4 wLevel=2
  c define: DM_CONN_MAX=1,xWSF_ASSERT_ENABLED=TRUE
  c misc: --c99
  c include: ..\..\..\..\ws-core\include;..\..\..\..\sw\stack\att;..\..\..\..\sw\stack\cfg;..\..\..\..\sw\stack\dm;..\..\..\..\sw\stack\include;..\..\..\..\sw\stack\l2c;..\..\..\..\sw\stack\smp;..\..\..\..\ws-core\sw\util;..\..\..\..\ws-core\sw\wsf\generic;..\..\..\..\ws-core\sw\wsf\include;..\..\..\..\sw\sec\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group att
    ../../../../sw/stack/att/: att_main.c att_uuid.c attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c
  group dm
    ../../../../sw/stack/dm/: dm_adv.c dm_adv_leg.c dm_adv_priv.c dm_conn.c dm_conn_master.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_main.c dm_priv.c dm_scan.c dm_scan_leg.c dm_sec.c dm_sec_master.c dm_sec_slave.c dm_sec_lesc.c
  group l2c
    ../../../../sw/stack/l2c/: l2c_main.c l2c_master.c l2c_slave.c
  group smp
    ../../../../sw/stack/smp/: smp_act.c smp_main.c smp_non.c smpi_act.c smpi_sm.c smpr_act.c smpr_sm.c smpr_sc_sm.c smpr_sc_act.c smp_sc_act.c smp_sc_main.c smpi_sc_act.c smpi_sc_sm.c
  group util
    ../../../../ws-core/sw/util/: bda.c calc128.c
