# Keil uVision project libam_hal.uvprojx, settings and files
target libam_hal (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: libam_hal (library)
  AfterMake: fromelf --bin --output bin\libam_hal.bin bin\libam_hal.axf
  AfterMake: fromelf -cedrst --output bin\libam_hal.txt bin\libam_hal.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_DEBUG_ASSERT AM_ASSERT_INVALID_THRESHOLD=0 AM_PART_APOLLO2 keil
  c include: ../../../../mcu/apollo2;../../../../utils
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x40000
  link misc: ../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group source_files
    ../: am_hal_adc.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_i2c_bit_bang.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_otp.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_ttp.c am_hal_uart.c am_hal_vcomp.c am_hal_wdt.c
