# Keil uVision project ble_app_buttonless_dfu_pca10040_s132.uvprojx, settings and files
target nrf52832_COD (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: application +hex
  AfterMake: cp .\COD/Output/application.hex ..\..\..\..\..\..\output\download_tool\application
  AfterMake: fromelf --bin --output ..\..\..\..\..\..\output\download_tool\application\application.bin .\COD\Output\application.axf
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: COD LAYER_APPLICATION FREERTOS BL_SETTINGS_ACCESS_ONLY CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=1 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=4096 __STACK_SIZE=2048 DEBUG
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\config;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\User\Task\APOLLO2;..\..\..\..\..\..\User\Driver\Apollo2;..\..\..\..\..\..\User\Device\APOLLO2;..\..\..\..\..\..\User\Command;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\User\Driver\BleFlash;..\..\..\..\..\..\User\Service\Apollo;..\..\..\..\..\..\User\Service\Nrf52;..\..\..\..\..\..\User\Device\ExtFlash;..\..\..\..\..\..\User\Driver\ExtFlash;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\User\Command;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\User\Service\Wechat;..\..\..\..\..\..\User\Task\BLE_CONN;..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\User\Service\ANCS;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\User\Task\ExtFlash;..\..\..\..\..\..\User\Library\Ambiq;..\..\..\..\..\..\User\Task\Central;..\..\..\..\..\..\User\Service\Accessary;..\..\..\..\..\..\User\Common;..\..\..\..\..\..\User\Task\Accessary;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\User\Library\Compression;..\..\..\..\..\..\User\Service\CSCS;..\..\..\..\..\..\User\Driver\WDT;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\ble_app_buttonless_dfu;..\..\..\..\..\..\User\codoon_ble_sdk\header;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\User\Service\COD;..\..\..\..\..\..\User\codoon_ble_sdk\header\utils
  asm define: JW901  BL_SETTINGS_ACCESS_ONLY BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBL_SETTINGS_ACCESS_ONLY,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_DFU_SVCI_ENABLED,-DNRF_SD_BLE_API_VERSION=5,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x38000
  memory RVCT9: RAM 0x20005a20 size 0xa5e0
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
    ../../../../../../User/Common/: watch_config.h
  group Task
    ../../../config/: FreeRTOSConfig.h
    ../../../../../../User/Task/APOLLO2/: task_apollo2.c
    ../../../../../../User/Task/BLE_CONN/: task_ble_conn.c
    ../../../../../../User/Task/ExtFlash/: task_extFlash.c
    ../../../../../../User/Task/Accessary/: task_ble_accessary.c
  group APP_Service
    ../../../../../../User/Service/Apollo/: app_srv_apollo.c
    ../../../../../../User/Service/Nrf52/: app_srv_nrf52.c
    ../../../../../../User/Service/ANCS/: app_srv_ancs.c
    ../../../../../../User/Service/Wechat/: app_srv_wechat.c
    ../../../../../../User/Service/Accessary/: app_srv_acces.c
    ../../../../../../User/Service/COD/: app_srv_cod.c
  group BLE_Services
    ../../../../../../User/Service/Apollo/: ble_srv_apollo.c
    ../../../../../../User/Service/Nrf52/: ble_srv_nrf52.c
    ../../../../../../User/Service/Wechat/: ble_srv_wechat.c
    ../../../../../../User/Service/CSCS/: ble_cscs_c.c
  group Device
    ../../../../../../User/Device/APOLLO2/: dev_apollo2.c
    ../../../../../../User/Device/ExtFlash/: dev_extFlash.c
  group Driver
    ../../../../../../User/Driver/Apollo2/: drv_apollo2.c
    ../../../../../../User/Driver/BleFlash/: drv_ble_flash.c
    ../../../../../../User/Driver/ExtFlash/: drv_extFlash.c
    ../../../../../../User/Driver/WDT/: drv_wdt.c
    ../../../../../../User/Driver/NFC/: drv_nfc_tag4.c
    ../../../../../../User/Driver/RTC_timer/: drv_rtc_timer.c
  group Library
    ../../../../../../User/Library/Ambiq/: am_bootloader.c
    ../../../../../../User/Library/Compression/: lib_quicklz.c
    ../../../../../../User/codoon_ble_sdk/header/: cod_ble_api.h cod_ble_bean.h cod_ble_cmd.h cod_ble_constants.h
    ../../../../../../User/codoon_ble_sdk/header/utils/: bytes_utils.h cod_ble_log.h cod_buffer.h cod_byte_buffer.h cod_crc_utils.h cod_list.h ring_buffer.h varint_utils.h
    ../../../../../../User/codoon_ble_sdk/header/processor/: cod_ble_processor.h
    ../../../../../../User/codoon_ble_sdk/header/generator/: cod_basic_cmd_gen.h cod_cmd_gen.h cod_data_trans_cmd_gen.h cod_ota_cmd_gen.h
    ../../../../../../User/codoon_ble_sdk/: ble_sdk_lib.lib
    ../../../../../../User/Common/: com_ringbuffer.c
  group Command
    ../../../../../../User/Command/: cmd_apollo2.h cmd_gpregret.h cmd_nrf52_srv.h cmd_apollo_srv.h
  group Third Parties
    ../../../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../external/freertos/source/portable/MemMang/: heap_1.c heap_2.c
    ../../../../../../external/freertos/portable/ARM/nrf52/: port.c
    ../../../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group nRF_BLE_Services
    ../../../../../../components/ble/ble_services/ble_ancs_c/: ancs_app_attr_get.c ancs_attr_parser.c ancs_tx_buffer.c nrf_ble_ancs_c.c
    ../../../../../../components/ble/ble_services/ble_hrs_c/: ble_hrs_c.c
    ../../../../../../components/ble/ble_services/ble_rscs_c/: ble_rscs_c.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
  group nRF_DFU
    ../../../../../../components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
  group nRF_Bootloader
    ../../../../../../components/libraries/bootloader/dfu/: nrf_dfu_settings.c nrf_dfu_flash.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../../../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c app_timer_freertos.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../components/libraries/uart/: app_uart.c app_uart_fifo.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../components/libraries/spi_mngr/: nrf_spi_mngr.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_SVC
    ../../../../../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c
    ../../../../../../components/nfc/t4t_lib/: nfc_t4t_lib_keil.lib
  group nRF_NFC
    ../../../../../../components/nfc/t4t_lib/hal_t4t/: hal_nfc_t4t.c
    ../../../../../../components/nfc/ndef/uri/: nfc_uri_msg.c nfc_uri_rec.c
    ../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
target flash_s132_nrf52_5.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s132_nrf52_5.0.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x55000
  memory RVCT9: RAM 0x20002180 size 0xde80
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.1.2, CMSIS:CORE 4.3.0, Device:Startup 8.15.0, Device:Startup 8.17.0
