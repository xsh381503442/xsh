# Keil uVision project yzl.uvprojx, settings and files
target COD (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: COD +hex
  AfterMake: fromelf --bin --output bin_cod\COD.bin bin_cod\COD.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: ERR_PRINT=1 AM_PACKAGE_BGA COD DEBUG_UTILS AM_FREERTOS keil DEBUG_ENABLED=1 AM_PART_APOLLO2 keil
  c include: ..\utils;..\apollo2;..\third_party\FreeRTOS\Source\include;..\third_party\FreeRTOS\Source\portable\Keil\AMapollo2;..\third_party\FreeRTOS\Source\portable\MemMang;..\third_party\RTT\RTT;..\third_party\RTT\syscalls;..\user\app;..\user\bsp;..\user\driver;..\user\font;..\user\gui_home;..\user\lib;..\user\task;..\user\gui_test;..\user\isr;..\user\mode;..\user\common;..\user\gui_tool;..\user\gui_menu;..\user\gui_sport;..\bootloader;..\devices;..\user\algo;..\user\gui;..\user\gui_notify;..\user\timer;..\user\command;..\user\lib\App_data;..\user\lib\Boot;..\user\lib\Boot_setting;..\user\lib\Encoding;..\user\lib\Error;..\user\lib\QrCoder;..\user\algo\heartrate\ohrl;..\user\algo\heartrate\si1181_driver
  memory RVCT4: ROM 0x0 size 0xe2000
  memory RVCT9: RAM 0x10000000 size 0x40000
  group app
    ../user/app/: app_config.h main.c rtos.c FreeRTOSConfig.h watch_config.h
  group bsp
    ../user/bsp/: bsp_config.h bsp.c bsp_iom.c bsp_rtc.c bsp_timer.c bsp_uart.c
  group isr
    ../user/isr/: isr_config.h isr_gpio.c isr_ctimer.c isr_iom.c isr_uart.c isr_clkgen.c
  group driver
    ../user/driver/: drv_config.h drv_lcd.c drv_key.c drv_gt24l24.c drv_motor.c drv_ublox.c drv_ms5837.c drv_buzzer.c drv_spiflash.c drv_heartrate.c drv_light.c drv_lis3mdl.c drv_battery.c drv_pc.c drv_intFlash.c drv_ble.c drv_extFlash.c drv_lsm6dsl.c drv_alarm.c drv_valencell.c drv_hrt.c drv_rtc_rv8803.c
    ../user/driver/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c
  group task
    ../user/task/: task_config.h task_key.c task_gps.c task_display.c task_step.c task_hardware.c task_timer.c task_uart.c task_tool.c task_battery.c task_pc.c task_ble.c task_hdr.c task_sport.c task_hrt.c
  group Time
    ../user/timer/: timer_config.h time_progress.c time_notify.c timer_app.c timer_traceback.c
  group mode
    ../user/mode/: mode_config.h mode_power_on.c mode_power_off.c
  group gui_test
    ../user/gui_test/: gui_gps_test.c gui_hwt.c gui_time_calibration_test.c gui_post_watch_info.c
  group gui
    ../user/gui/: gui_config.h gui.c gui_clockline.c gui_dial.c gui_dfu.c
  group gui_home
    ../user/gui_home/: gui_home_config.h gui_home.c gui_heartrate.c gui_step.c gui_VO2max.c gui_motionsrecord.c gui_notification.c gui_calories.c gui_lactate_threshold.c gui_trainplan.c gui_recovery.c
  group gui_tool
    ../user/gui_tool/: gui_tool_config.h gui_tool.c gui_tool_calendar.c gui_tool_ambient.c gui_tool_gps.c gui_tool_compass.c gui_tool_stopwatch.c gui_tool_findphone.c gui_tool_countdown.c
  group gui_sport
    ../user/gui_sport/: gui_sport_config.h gui_sport.c gui_run.c gui_sport_cycling.c gui_sport_crosscountry_hike.c gui_climbing.c gui_swimming.c gui_sport_triathlon.c gui_crosscountry.c gui_sport_indoorrun.c gui_sport_walk.c gui_sport_marathon.c
  group gui_menu
    ../user/gui_menu/: gui_menu_config.h gui_menu.c gui_theme.c gui_time.c gui_sports_record.c gui_accessory.c gui_system.c gui_watch_info.c gui_customized_sports.c gui_customized_tools.c gui_xt_ble_auth.c
  group gui_notify
    ../user/gui_notify/: gui_notify_ble.c gui_notify_alarm.c gui_notify_app_msg.c gui_notify_base_hdr.c gui_notify_bat.c gui_notify_sport.c gui_notify_train.c gui_notify_warning.c gui_notify_ble_dfu.c
  group common
    ../user/common/: com_config.h com_data.c com_sport.c com_dial.c com_ringbuffer.c
  group algo
    ../user/algo/: algo_config.h algo_hdr.c algo_time_calibration.c algo_sport.c algo_trainplan.c algo_trackoptimizing.c algo_swimming.c algo_trackjudge.c algo_gauss.c algo_sport_cycling.c algo_step_count.c algo_imu_calibration.c algo_HF_swimming_main.cpp algo_MatFun.c algo_magn_cal.c
    ../user/algo/heartrate/si1181_driver/: si117x_config.c si117x_functions.c
    ../user/algo/heartrate/ohrl/: OHRL_AMBIQ2.lib
  group font
    ../user/font/: font_config.h font_displaystrs.c font_char.c font_chinese.c font_number.c img_background.c img_home.c img_sport.c img_tool.c img_weather.c img_menu.c img_dial.c string_CN.c string_EN.c img_notify.c
  group Command
    ../user/command/: cmd_pc.h cmd_ble.h
  group lib
    ../user/lib/: lib_config.h lib_log.c HFMA2Y.lib HFMA2Ylib.h
    ../user/lib/Compass/: AKFS_AOC.c AKFS_Decomp.c AKFS_Device.c AKFS_Direction.c AKFS_VNorm.c akm_oss_wrapper.c
    ../user/lib/Pedometer/: Pedometer.c
    ../user/lib/GT60M2/: GT60M2.h GT60M2_LTF.lib
  group FreeRTOS
    ../third_party/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../third_party/FreeRTOS/Source/portable/Keil/AMapollo2/: port.c
  group RTT
    ../third_party/RTT/RTT/: SEGGER_RTT_Conf.h SEGGER_RTT.c SEGGER_RTT_printf.c
  group am_utils
    ../utils/: am_util_delay.c am_util_faultisr.c am_util_plot.c am_util_ring_buffer.c am_util_stdio.c am_util_stopwatch.c am_util_math.c am_util_time.c am_util_string.c
  group am_lib
    ../apollo2/hal/: am_hal_adc.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_i2c_bit_bang.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_otp.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_ttp.c am_hal_uart.c am_hal_vcomp.c am_hal_wdt.c
  group StartUp
    ./: startup_keil.s
  group Library
    ../user/lib/Boot/: lib_boot.c
    ../user/lib/Boot_setting/: lib_boot_setting.c
    ../user/lib/Error/: lib_error.c
    ../user/lib/App_data/: lib_app_data.c
    ../user/lib/Encoding/: lib_utf8_gbk.c
  group am_boot
    ../bootloader/: am_bootloader.c
  group QrCoder
    ../user/lib/QrCoder/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
target HY100 (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: as above
  output: HY100 +hex
  AfterMake: fromelf --bin --output bin_hy100\hy100.bin bin_hy100\hy100.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: ERR_PRINT=1 AM_PACKAGE_BGA HY100 DEBUG_UTILS AM_FREERTOS keil DEBUG_ENABLED=0 AM_PART_APOLLO2 keil
  c include: as above
  memory RVCT4: ROM 0x0 size 0xe2000
  memory RVCT9: RAM 0x10000000 size 0x40000
